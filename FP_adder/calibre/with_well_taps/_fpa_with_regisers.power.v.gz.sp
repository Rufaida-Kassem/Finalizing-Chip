$ Spice netlist generated by v2lvs
$ v2020.1_25.14    Mon Feb 3 16:40:08 PST 2020
*.BUSDELIMITER [

.SUBCKT registerNbits clk_CTSPP_1 VDD VSS clk reset en inp[31] inp[30] inp[29]
+ inp[28] inp[27] inp[26] inp[25] inp[24] inp[23] inp[22] inp[21] inp[20]
+ inp[19] inp[18] inp[17] inp[16] inp[15] inp[14] inp[13] inp[12] inp[11]
+ inp[10] inp[9] inp[8] inp[7] inp[6] inp[5] inp[4] inp[3] inp[2] inp[1] inp[0]
+ out[31] out[30] out[29] out[28] out[27] out[26] out[25] out[24] out[23]
+ out[22] out[21] out[20] out[19] out[18] out[17] out[16] out[15] out[14]
+ out[13] out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5] out[4]
+ out[3] out[2] out[1] out[0]
Xi_0_33 AND2_X1 $PINS ZN=n_33 A1=n_0_0 A2=inp[31] VDD=VDD VSS=VSS
Xi_0_32 AND2_X1 $PINS ZN=n_32 A1=n_0_0 A2=inp[30] VDD=VDD VSS=VSS
Xi_0_31 AND2_X1 $PINS ZN=n_31 A1=n_0_0 A2=inp[29] VDD=VDD VSS=VSS
Xi_0_30 AND2_X1 $PINS ZN=n_30 A1=n_0_0 A2=inp[28] VDD=VDD VSS=VSS
Xi_0_29 AND2_X1 $PINS ZN=n_29 A1=n_0_0 A2=inp[27] VDD=VDD VSS=VSS
Xi_0_28 AND2_X1 $PINS ZN=n_28 A1=n_0_0 A2=inp[26] VDD=VDD VSS=VSS
Xi_0_27 AND2_X1 $PINS ZN=n_27 A1=n_0_0 A2=inp[25] VDD=VDD VSS=VSS
Xi_0_26 AND2_X1 $PINS ZN=n_26 A1=n_0_0 A2=inp[24] VDD=VDD VSS=VSS
Xi_0_25 AND2_X1 $PINS ZN=n_25 A1=n_0_0 A2=inp[23] VDD=VDD VSS=VSS
Xi_0_24 AND2_X1 $PINS ZN=n_24 A1=n_0_0 A2=inp[22] VDD=VDD VSS=VSS
Xi_0_23 AND2_X1 $PINS ZN=n_23 A1=n_0_0 A2=inp[21] VDD=VDD VSS=VSS
Xi_0_22 AND2_X1 $PINS ZN=n_22 A1=n_0_0 A2=inp[20] VDD=VDD VSS=VSS
Xi_0_21 AND2_X1 $PINS ZN=n_21 A1=n_0_0 A2=inp[19] VDD=VDD VSS=VSS
Xi_0_20 AND2_X1 $PINS ZN=n_20 A1=n_0_0 A2=inp[18] VDD=VDD VSS=VSS
Xi_0_19 AND2_X1 $PINS ZN=n_19 A1=n_0_0 A2=inp[17] VDD=VDD VSS=VSS
Xi_0_18 AND2_X1 $PINS ZN=n_18 A1=n_0_0 A2=inp[16] VDD=VDD VSS=VSS
Xi_0_17 AND2_X1 $PINS ZN=n_17 A1=n_0_0 A2=inp[15] VDD=VDD VSS=VSS
Xi_0_16 AND2_X1 $PINS ZN=n_16 A1=n_0_0 A2=inp[14] VDD=VDD VSS=VSS
Xi_0_15 AND2_X1 $PINS ZN=n_15 A1=n_0_0 A2=inp[13] VDD=VDD VSS=VSS
Xi_0_14 AND2_X1 $PINS ZN=n_14 A1=n_0_0 A2=inp[12] VDD=VDD VSS=VSS
Xi_0_13 AND2_X1 $PINS ZN=n_13 A1=n_0_0 A2=inp[11] VDD=VDD VSS=VSS
Xi_0_12 AND2_X1 $PINS ZN=n_12 A1=n_0_0 A2=inp[10] VDD=VDD VSS=VSS
Xi_0_11 AND2_X1 $PINS ZN=n_11 A1=n_0_0 A2=inp[9] VDD=VDD VSS=VSS
Xi_0_10 AND2_X1 $PINS ZN=n_10 A1=n_0_0 A2=inp[8] VDD=VDD VSS=VSS
Xi_0_9 AND2_X1 $PINS ZN=n_9 A1=n_0_0 A2=inp[7] VDD=VDD VSS=VSS
Xi_0_8 AND2_X1 $PINS ZN=n_8 A1=n_0_0 A2=inp[6] VDD=VDD VSS=VSS
Xi_0_7 AND2_X1 $PINS ZN=n_7 A1=n_0_0 A2=inp[5] VDD=VDD VSS=VSS
Xi_0_6 AND2_X1 $PINS ZN=n_6 A1=n_0_0 A2=inp[4] VDD=VDD VSS=VSS
Xi_0_5 AND2_X1 $PINS ZN=n_5 A1=n_0_0 A2=inp[3] VDD=VDD VSS=VSS
Xi_0_4 AND2_X1 $PINS ZN=n_4 A1=n_0_0 A2=inp[2] VDD=VDD VSS=VSS
Xi_0_3 AND2_X1 $PINS ZN=n_3 A1=n_0_0 A2=inp[1] VDD=VDD VSS=VSS
Xi_0_2 AND2_X1 $PINS ZN=n_2 A1=n_0_0 A2=inp[0] VDD=VDD VSS=VSS
Xi_0_1 INV_X1 $PINS ZN=n_0_0 A=reset VDD=VDD VSS=VSS
Xi_0_0 OR2_X1 $PINS ZN=n_1 A1=en A2=reset VDD=VDD VSS=VSS
Xout_reg[0] DFF_X1 $PINS Q=out[0] CK=CTS_n2 D=n_2 VDD=VDD VSS=VSS
Xout_reg[1] DFF_X1 $PINS Q=out[1] CK=CTS_n2 D=n_3 VDD=VDD VSS=VSS
Xout_reg[2] DFF_X1 $PINS Q=out[2] CK=CTS_n2 D=n_4 VDD=VDD VSS=VSS
Xout_reg[3] DFF_X1 $PINS Q=out[3] CK=CTS_n2 D=n_5 VDD=VDD VSS=VSS
Xout_reg[4] DFF_X1 $PINS Q=out[4] CK=CTS_n2 D=n_6 VDD=VDD VSS=VSS
Xout_reg[5] DFF_X1 $PINS Q=out[5] CK=CTS_n2 D=n_7 VDD=VDD VSS=VSS
Xout_reg[6] DFF_X1 $PINS Q=out[6] CK=CTS_n2 D=n_8 VDD=VDD VSS=VSS
Xout_reg[7] DFF_X1 $PINS Q=out[7] CK=CTS_n2 D=n_9 VDD=VDD VSS=VSS
Xout_reg[8] DFF_X1 $PINS Q=out[8] CK=CTS_n2 D=n_10 VDD=VDD VSS=VSS
Xout_reg[9] DFF_X1 $PINS Q=out[9] CK=CTS_n2 D=n_11 VDD=VDD VSS=VSS
Xout_reg[10] DFF_X1 $PINS Q=out[10] CK=CTS_n2 D=n_12 VDD=VDD VSS=VSS
Xout_reg[11] DFF_X1 $PINS Q=out[11] CK=CTS_n2 D=n_13 VDD=VDD VSS=VSS
Xout_reg[12] DFF_X1 $PINS Q=out[12] CK=CTS_n2 D=n_14 VDD=VDD VSS=VSS
Xout_reg[13] DFF_X1 $PINS Q=out[13] CK=CTS_n2 D=n_15 VDD=VDD VSS=VSS
Xout_reg[14] DFF_X1 $PINS Q=out[14] CK=CTS_n2 D=n_16 VDD=VDD VSS=VSS
Xout_reg[15] DFF_X1 $PINS Q=out[15] CK=CTS_n2 D=n_17 VDD=VDD VSS=VSS
Xout_reg[16] DFF_X1 $PINS Q=out[16] CK=CTS_n2 D=n_18 VDD=VDD VSS=VSS
Xout_reg[17] DFF_X1 $PINS Q=out[17] CK=CTS_n2 D=n_19 VDD=VDD VSS=VSS
Xout_reg[18] DFF_X1 $PINS Q=out[18] CK=CTS_n2 D=n_20 VDD=VDD VSS=VSS
Xout_reg[19] DFF_X1 $PINS Q=out[19] CK=CTS_n2 D=n_21 VDD=VDD VSS=VSS
Xout_reg[20] DFF_X1 $PINS Q=out[20] CK=CTS_n2 D=n_22 VDD=VDD VSS=VSS
Xout_reg[21] DFF_X1 $PINS Q=out[21] CK=CTS_n2 D=n_23 VDD=VDD VSS=VSS
Xout_reg[22] DFF_X1 $PINS Q=out[22] CK=CTS_n2 D=n_24 VDD=VDD VSS=VSS
Xout_reg[23] DFF_X1 $PINS Q=out[23] CK=CTS_n2 D=n_25 VDD=VDD VSS=VSS
Xout_reg[24] DFF_X1 $PINS Q=out[24] CK=CTS_n2 D=n_26 VDD=VDD VSS=VSS
Xout_reg[25] DFF_X1 $PINS Q=out[25] CK=CTS_n2 D=n_27 VDD=VDD VSS=VSS
Xout_reg[26] DFF_X1 $PINS Q=out[26] CK=CTS_n2 D=n_28 VDD=VDD VSS=VSS
Xout_reg[27] DFF_X1 $PINS Q=out[27] CK=CTS_n2 D=n_29 VDD=VDD VSS=VSS
Xout_reg[28] DFF_X1 $PINS Q=out[28] CK=CTS_n2 D=n_30 VDD=VDD VSS=VSS
Xout_reg[29] DFF_X1 $PINS Q=out[29] CK=CTS_n2 D=n_31 VDD=VDD VSS=VSS
Xout_reg[30] DFF_X1 $PINS Q=out[30] CK=CTS_n2 D=n_32 VDD=VDD VSS=VSS
Xout_reg[31] DFF_X1 $PINS Q=out[31] CK=CTS_n2 D=n_33 VDD=VDD VSS=VSS
Xclk_gate_out_reg CLKGATETST_X8 $PINS GCK=CTS_n3 CK=clk_CTSPP_1 E=n_1 SE=VSS
+ VDD=VDD VSS=VSS
XCTS_L3_c3 CLKBUF_X3 $PINS Z=CTS_n2 A=CTS_n3 VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_4bit VDD VSS x[3] x[2] x[1] x[0] y[3] y[2] y[1] y[0] cO s[3] s[2]
+ s[1] s[0] p g
Xi_0_10 XNOR2_X1 $PINS ZN=n_0_7 A=x[3] B=n_0_2 VDD=VDD VSS=VSS
Xi_0_9 XNOR2_X1 $PINS ZN=s[3] A=y[3] B=n_0_7 VDD=VDD VSS=VSS
Xi_0_8 OAI22_X1 $PINS ZN=n_0_6 A1=y[3] A2=x[3] B1=x[2] B2=y[2] VDD=VDD VSS=VSS
Xi_0_7 OAI22_X1 $PINS ZN=n_0_5 A1=y[1] A2=x[1] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_6 NOR2_X1 $PINS ZN=p A1=n_0_6 A2=n_0_5 VDD=VDD VSS=VSS
Xi_0_5 NAND2_X1 $PINS ZN=n_0_4 A1=y[3] A2=x[3] VDD=VDD VSS=VSS
Xi_0_4 AOI22_X1 $PINS ZN=n_0_3 A1=y[2] A2=x[2] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_3 OAI21_X1 $PINS ZN=g A=n_0_4 B1=n_0_3 B2=n_0_6 VDD=VDD VSS=VSS
Xi_0_2 FA_X1 $PINS CO=n_0_2 S=s[2] A=y[2] B=x[2] CI=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 FA_X1 $PINS CO=n_0_1 S=s[1] A=y[1] B=x[1] CI=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 FA_X1 $PINS CO=n_0_0 S=s[0] A=cO B=x[0] CI=y[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_4bit__0_146 VDD VSS x[3] x[2] x[1] x[0] y[3] y[2] y[1] y[0] cO s[3]
+ s[2] s[1] s[0] p g
Xi_0_10 XNOR2_X1 $PINS ZN=n_0_7 A=x[3] B=n_0_2 VDD=VDD VSS=VSS
Xi_0_9 XNOR2_X1 $PINS ZN=s[3] A=y[3] B=n_0_7 VDD=VDD VSS=VSS
Xi_0_8 OAI22_X1 $PINS ZN=n_0_6 A1=y[3] A2=x[3] B1=x[2] B2=y[2] VDD=VDD VSS=VSS
Xi_0_7 OAI22_X1 $PINS ZN=n_0_5 A1=y[1] A2=x[1] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_6 NOR2_X1 $PINS ZN=p A1=n_0_6 A2=n_0_5 VDD=VDD VSS=VSS
Xi_0_5 NAND2_X1 $PINS ZN=n_0_4 A1=y[3] A2=x[3] VDD=VDD VSS=VSS
Xi_0_4 AOI22_X1 $PINS ZN=n_0_3 A1=y[2] A2=x[2] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_3 OAI21_X1 $PINS ZN=g A=n_0_4 B1=n_0_3 B2=n_0_6 VDD=VDD VSS=VSS
Xi_0_2 FA_X1 $PINS CO=n_0_2 S=s[2] A=y[2] B=x[2] CI=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 FA_X1 $PINS CO=n_0_1 S=s[1] A=y[1] B=x[1] CI=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 FA_X1 $PINS CO=n_0_0 S=s[0] A=cO B=x[0] CI=y[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_4bit__0_138 VDD VSS x[3] x[2] x[1] x[0] y[3] y[2] y[1] y[0] cO s[3]
+ s[2] s[1] s[0] p g
Xi_0_10 XNOR2_X1 $PINS ZN=n_0_7 A=x[3] B=n_0_2 VDD=VDD VSS=VSS
Xi_0_9 XNOR2_X1 $PINS ZN=s[3] A=y[3] B=n_0_7 VDD=VDD VSS=VSS
Xi_0_8 OAI22_X1 $PINS ZN=n_0_6 A1=y[3] A2=x[3] B1=x[2] B2=y[2] VDD=VDD VSS=VSS
Xi_0_7 OAI22_X1 $PINS ZN=n_0_5 A1=y[1] A2=x[1] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_6 NOR2_X1 $PINS ZN=p A1=n_0_6 A2=n_0_5 VDD=VDD VSS=VSS
Xi_0_5 NAND2_X1 $PINS ZN=n_0_4 A1=y[3] A2=x[3] VDD=VDD VSS=VSS
Xi_0_4 AOI22_X1 $PINS ZN=n_0_3 A1=y[2] A2=x[2] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_3 OAI21_X1 $PINS ZN=g A=n_0_4 B1=n_0_3 B2=n_0_6 VDD=VDD VSS=VSS
Xi_0_2 FA_X1 $PINS CO=n_0_2 S=s[2] A=y[2] B=x[2] CI=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 FA_X1 $PINS CO=n_0_1 S=s[1] A=y[1] B=x[1] CI=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 FA_X1 $PINS CO=n_0_0 S=s[0] A=cO B=x[0] CI=y[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_4bit__0_130 VDD VSS x[3] x[2] x[1] x[0] y[3] y[2] y[1] y[0] cO s[3]
+ s[2] s[1] s[0] p g
Xi_0_10 XNOR2_X1 $PINS ZN=n_0_7 A=x[3] B=n_0_2 VDD=VDD VSS=VSS
Xi_0_9 XNOR2_X1 $PINS ZN=s[3] A=y[3] B=n_0_7 VDD=VDD VSS=VSS
Xi_0_8 OAI22_X1 $PINS ZN=n_0_6 A1=y[3] A2=x[3] B1=x[2] B2=y[2] VDD=VDD VSS=VSS
Xi_0_7 OAI22_X1 $PINS ZN=n_0_5 A1=y[1] A2=x[1] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_6 NOR2_X1 $PINS ZN=p A1=n_0_6 A2=n_0_5 VDD=VDD VSS=VSS
Xi_0_5 NAND2_X1 $PINS ZN=n_0_4 A1=y[3] A2=x[3] VDD=VDD VSS=VSS
Xi_0_4 AOI22_X1 $PINS ZN=n_0_3 A1=y[2] A2=x[2] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_3 OAI21_X1 $PINS ZN=g A=n_0_4 B1=n_0_3 B2=n_0_6 VDD=VDD VSS=VSS
Xi_0_2 FA_X1 $PINS CO=n_0_2 S=s[2] A=y[2] B=x[2] CI=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 FA_X1 $PINS CO=n_0_1 S=s[1] A=y[1] B=x[1] CI=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 FA_X1 $PINS CO=n_0_0 S=s[0] A=cO B=x[0] CI=y[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_4bit__0_122 VDD VSS x[3] x[2] x[1] x[0] y[3] y[2] y[1] y[0] cO s[3]
+ s[2] s[1] s[0] p g
Xi_0_10 XNOR2_X1 $PINS ZN=n_0_7 A=x[3] B=n_0_2 VDD=VDD VSS=VSS
Xi_0_9 XNOR2_X1 $PINS ZN=s[3] A=y[3] B=n_0_7 VDD=VDD VSS=VSS
Xi_0_8 OAI22_X1 $PINS ZN=n_0_6 A1=y[3] A2=x[3] B1=x[2] B2=y[2] VDD=VDD VSS=VSS
Xi_0_7 OAI22_X1 $PINS ZN=n_0_5 A1=y[1] A2=x[1] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_6 NOR2_X1 $PINS ZN=p A1=n_0_6 A2=n_0_5 VDD=VDD VSS=VSS
Xi_0_5 NAND2_X1 $PINS ZN=n_0_4 A1=y[3] A2=x[3] VDD=VDD VSS=VSS
Xi_0_4 AOI22_X1 $PINS ZN=n_0_3 A1=y[2] A2=x[2] B1=x[0] B2=y[0] VDD=VDD VSS=VSS
Xi_0_3 OAI21_X1 $PINS ZN=g A=n_0_4 B1=n_0_3 B2=n_0_6 VDD=VDD VSS=VSS
Xi_0_2 FA_X1 $PINS CO=n_0_2 S=s[2] A=y[2] B=x[2] CI=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 FA_X1 $PINS CO=n_0_1 S=s[1] A=y[1] B=x[1] CI=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 FA_X1 $PINS CO=n_0_0 S=s[0] A=cO B=x[0] CI=y[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_4bit__0_114 VDD VSS x[3] x[2] x[1] x[0] y[3] y[2] y[1] y[0] cO s[3]
+ s[2] s[1] s[0] p g
Xi_0_8 XNOR2_X1 $PINS ZN=n_0_6 A=x[3] B=n_0_2 VDD=VDD VSS=VSS
Xi_0_7 XNOR2_X1 $PINS ZN=s[3] A=y[3] B=n_0_6 VDD=VDD VSS=VSS
Xi_0_6 NOR2_X1 $PINS ZN=n_0_5 A1=y[3] A2=x[3] VDD=VDD VSS=VSS
Xi_0_5 OAI211_X1 $PINS ZN=n_0_4 A=y[0] B=x[0] C1=x[2] C2=y[2] VDD=VDD VSS=VSS
Xi_0_4 AOI22_X1 $PINS ZN=n_0_3 A1=y[3] A2=x[3] B1=x[2] B2=y[2] VDD=VDD VSS=VSS
Xi_0_3 AOI21_X1 $PINS ZN=g A=n_0_5 B1=n_0_3 B2=n_0_4 VDD=VDD VSS=VSS
Xi_0_2 FA_X1 $PINS CO=n_0_2 S=s[2] A=y[2] B=x[2] CI=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 FA_X1 $PINS CO=n_0_1 S=s[1] A=y[1] B=x[1] CI=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 FA_X1 $PINS CO=n_0_0 S=s[0] A=VSS B=x[0] CI=y[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT CLA_adder VDD VSS A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15]
+ A[14] A[13] A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1]
+ A[0] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14] B[13] B[12]
+ B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0] Cin Sum[23]
+ Sum[22] Sum[21] Sum[20] Sum[19] Sum[18] Sum[17] Sum[16] Sum[15] Sum[14]
+ Sum[13] Sum[12] Sum[11] Sum[10] Sum[9] Sum[8] Sum[7] Sum[6] Sum[5] Sum[4]
+ Sum[3] Sum[2] Sum[1] Sum[0] Cout Overflow
Xi_1_9 INV_X1 $PINS ZN=Cout A=n_1_4 VDD=VDD VSS=VSS
Xi_1_8 AOI21_X1 $PINS ZN=n_1_4 A=n_8 B1=n_9 B2=n_13 VDD=VDD VSS=VSS
Xi_1_7 INV_X1 $PINS ZN=n_13 A=n_1_3 VDD=VDD VSS=VSS
Xi_1_6 AOI21_X1 $PINS ZN=n_1_3 A=n_6 B1=n_7 B2=n_12 VDD=VDD VSS=VSS
Xi_1_5 INV_X1 $PINS ZN=n_12 A=n_1_2 VDD=VDD VSS=VSS
Xi_1_4 AOI21_X1 $PINS ZN=n_1_2 A=n_4 B1=n_5 B2=n_11 VDD=VDD VSS=VSS
Xi_1_3 INV_X1 $PINS ZN=n_11 A=n_1_1 VDD=VDD VSS=VSS
Xi_1_2 AOI21_X1 $PINS ZN=n_1_1 A=n_2 B1=n_3 B2=n_10 VDD=VDD VSS=VSS
Xi_1_1 INV_X1 $PINS ZN=n_10 A=n_1_0 VDD=VDD VSS=VSS
Xi_1_0 AOI21_X1 $PINS ZN=n_1_0 A=n_0 B1=n_1 B2=w_G VDD=VDD VSS=VSS
Xi_0_2 NOR2_X1 $PINS ZN=Overflow A1=n_0_0 A2=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 XNOR2_X1 $PINS ZN=n_0_1 A=A[23] B=Sum[23] VDD=VDD VSS=VSS
Xi_0_0 XOR2_X1 $PINS Z=n_0_0 A=A[23] B=B[23] VDD=VDD VSS=VSS
Xgenblk1_5_stage1 CLA_4bit $PINS g=n_8 p=n_9 s[3]=Sum[23] s[2]=Sum[22]
+ s[1]=Sum[21] s[0]=Sum[20] cO=n_13 x[3]=A[23] x[2]=A[22] x[1]=A[21] x[0]=A[20]
+ y[3]=B[23] y[2]=B[22] y[1]=B[21] y[0]=B[20] VDD=VDD VSS=VSS
Xgenblk1_4_stage1 CLA_4bit__0_146 $PINS g=n_6 p=n_7 s[3]=Sum[19] s[2]=Sum[18]
+ s[1]=Sum[17] s[0]=Sum[16] cO=n_12 x[3]=A[19] x[2]=A[18] x[1]=A[17] x[0]=A[16]
+ y[3]=B[19] y[2]=B[18] y[1]=B[17] y[0]=B[16] VDD=VDD VSS=VSS
Xgenblk1_3_stage1 CLA_4bit__0_138 $PINS g=n_4 p=n_5 s[3]=Sum[15] s[2]=Sum[14]
+ s[1]=Sum[13] s[0]=Sum[12] cO=n_11 x[3]=A[15] x[2]=A[14] x[1]=A[13] x[0]=A[12]
+ y[3]=B[15] y[2]=B[14] y[1]=B[13] y[0]=B[12] VDD=VDD VSS=VSS
Xgenblk1_2_stage1 CLA_4bit__0_130 $PINS g=n_2 p=n_3 s[3]=Sum[11] s[2]=Sum[10]
+ s[1]=Sum[9] s[0]=Sum[8] cO=n_10 x[3]=A[11] x[2]=A[10] x[1]=A[9] x[0]=A[8]
+ y[3]=B[11] y[2]=B[10] y[1]=B[9] y[0]=B[8] VDD=VDD VSS=VSS
Xgenblk1_1_stage1 CLA_4bit__0_122 $PINS g=n_0 p=n_1 s[3]=Sum[7] s[2]=Sum[6]
+ s[1]=Sum[5] s[0]=Sum[4] cO=w_G x[3]=A[7] x[2]=A[6] x[1]=A[5] x[0]=A[4]
+ y[3]=B[7] y[2]=B[6] y[1]=B[5] y[0]=B[4] VDD=VDD VSS=VSS
Xgenblk1_0_stage1 CLA_4bit__0_114 $PINS g=w_G s[3]=Sum[3] s[2]=Sum[2]
+ s[1]=Sum[1] s[0]=Sum[0] x[3]=A[3] x[2]=A[2] x[1]=A[1] x[0]=A[0] y[3]=B[3]
+ y[2]=B[2] y[1]=B[1] y[0]=B[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT addition_normaliser VDD VSS in_e[7] in_e[6] in_e[5] in_e[4] in_e[3]
+ in_e[2] in_e[1] in_e[0] in_m[24] in_m[23] in_m[22] in_m[21] in_m[20] in_m[19]
+ in_m[18] in_m[17] in_m[16] in_m[15] in_m[14] in_m[13] in_m[12] in_m[11]
+ in_m[10] in_m[9] in_m[8] in_m[7] in_m[6] in_m[5] in_m[4] in_m[3] in_m[2]
+ in_m[1] in_m[0] out_e[7] out_e[6] out_e[5] out_e[4] out_e[3] out_e[2]
+ out_e[1] out_e[0] out_m[24] out_m[23] out_m[22] out_m[21] out_m[20] out_m[19]
+ out_m[18] out_m[17] out_m[16] out_m[15] out_m[14] out_m[13] out_m[12]
+ out_m[11] out_m[10] out_m[9] out_m[8] out_m[7] out_m[6] out_m[5] out_m[4]
+ out_m[3] out_m[2] out_m[1] out_m[0]
Xi_0_530 INV_X1 $PINS ZN=n_0_514 A=in_e[6] VDD=VDD VSS=VSS
Xi_0_529 INV_X1 $PINS ZN=n_0_513 A=in_e[3] VDD=VDD VSS=VSS
Xi_0_528 INV_X1 $PINS ZN=n_0_512 A=in_e[2] VDD=VDD VSS=VSS
Xi_0_527 INV_X1 $PINS ZN=n_0_511 A=in_e[1] VDD=VDD VSS=VSS
Xi_0_526 INV_X1 $PINS ZN=n_0_510 A=in_e[0] VDD=VDD VSS=VSS
Xi_0_525 INV_X1 $PINS ZN=n_0_509 A=in_m[21] VDD=VDD VSS=VSS
Xi_0_524 INV_X1 $PINS ZN=n_0_508 A=in_m[20] VDD=VDD VSS=VSS
Xi_0_523 INV_X1 $PINS ZN=n_0_507 A=in_m[19] VDD=VDD VSS=VSS
Xi_0_522 INV_X1 $PINS ZN=n_0_506 A=in_m[18] VDD=VDD VSS=VSS
Xi_0_521 INV_X1 $PINS ZN=n_0_505 A=in_m[17] VDD=VDD VSS=VSS
Xi_0_520 INV_X1 $PINS ZN=n_0_504 A=in_m[16] VDD=VDD VSS=VSS
Xi_0_519 INV_X1 $PINS ZN=n_0_503 A=in_m[15] VDD=VDD VSS=VSS
Xi_0_518 INV_X1 $PINS ZN=n_0_502 A=in_m[14] VDD=VDD VSS=VSS
Xi_0_517 INV_X1 $PINS ZN=n_0_501 A=in_m[13] VDD=VDD VSS=VSS
Xi_0_516 INV_X1 $PINS ZN=n_0_500 A=in_m[12] VDD=VDD VSS=VSS
Xi_0_515 INV_X1 $PINS ZN=n_0_499 A=in_m[11] VDD=VDD VSS=VSS
Xi_0_514 INV_X1 $PINS ZN=n_0_498 A=in_m[10] VDD=VDD VSS=VSS
Xi_0_513 INV_X1 $PINS ZN=n_0_497 A=in_m[9] VDD=VDD VSS=VSS
Xi_0_512 INV_X1 $PINS ZN=n_0_496 A=in_m[8] VDD=VDD VSS=VSS
Xi_0_511 INV_X1 $PINS ZN=n_0_495 A=in_m[7] VDD=VDD VSS=VSS
Xi_0_510 INV_X1 $PINS ZN=n_0_494 A=in_m[6] VDD=VDD VSS=VSS
Xi_0_509 INV_X1 $PINS ZN=n_0_493 A=in_m[5] VDD=VDD VSS=VSS
Xi_0_508 INV_X1 $PINS ZN=n_0_492 A=in_m[4] VDD=VDD VSS=VSS
Xi_0_507 INV_X1 $PINS ZN=n_0_491 A=in_m[3] VDD=VDD VSS=VSS
Xi_0_506 INV_X1 $PINS ZN=n_0_490 A=in_m[2] VDD=VDD VSS=VSS
Xi_0_505 INV_X1 $PINS ZN=n_0_489 A=in_m[1] VDD=VDD VSS=VSS
Xi_0_504 INV_X1 $PINS ZN=n_0_488 A=n_0_2 VDD=VDD VSS=VSS
Xi_0_503 INV_X1 $PINS ZN=n_0_487 A=n_0_12 VDD=VDD VSS=VSS
Xi_0_502 INV_X1 $PINS ZN=n_0_486 A=n_0_29 VDD=VDD VSS=VSS
Xi_0_501 INV_X1 $PINS ZN=n_0_485 A=n_0_14 VDD=VDD VSS=VSS
Xi_0_500 NOR2_X2 $PINS ZN=n_0_484 A1=in_m[23] A2=in_m[22] VDD=VDD VSS=VSS
Xi_0_499 INV_X1 $PINS ZN=n_0_483 A=n_0_484 VDD=VDD VSS=VSS
Xi_0_498 NAND2_X1 $PINS ZN=n_0_482 A1=n_0_508 A2=n_0_484 VDD=VDD VSS=VSS
Xi_0_497 INV_X1 $PINS ZN=n_0_481 A=n_0_482 VDD=VDD VSS=VSS
Xi_0_496 NAND2_X1 $PINS ZN=n_0_480 A1=n_0_509 A2=n_0_484 VDD=VDD VSS=VSS
Xi_0_495 INV_X1 $PINS ZN=n_0_479 A=n_0_480 VDD=VDD VSS=VSS
Xi_0_494 NAND2_X1 $PINS ZN=n_0_478 A1=n_0_509 A2=n_0_481 VDD=VDD VSS=VSS
Xi_0_493 INV_X1 $PINS ZN=n_0_477 A=n_0_478 VDD=VDD VSS=VSS
Xi_0_492 NAND2_X1 $PINS ZN=n_0_476 A1=n_0_507 A2=n_0_505 VDD=VDD VSS=VSS
Xi_0_491 INV_X1 $PINS ZN=n_0_475 A=n_0_476 VDD=VDD VSS=VSS
Xi_0_490 NOR2_X1 $PINS ZN=n_0_474 A1=in_m[19] A2=in_m[18] VDD=VDD VSS=VSS
Xi_0_489 NOR2_X1 $PINS ZN=n_0_473 A1=in_m[18] A2=n_0_476 VDD=VDD VSS=VSS
Xi_0_488 NAND2_X1 $PINS ZN=n_0_472 A1=n_0_477 A2=n_0_473 VDD=VDD VSS=VSS
Xi_0_487 INV_X1 $PINS ZN=n_0_471 A=n_0_472 VDD=VDD VSS=VSS
Xi_0_486 OAI21_X1 $PINS ZN=n_0_470 A=n_0_503 B1=in_m[16] B2=n_0_501 VDD=VDD
+ VSS=VSS
Xi_0_485 NOR2_X1 $PINS ZN=n_0_469 A1=in_m[16] A2=in_m[15] VDD=VDD VSS=VSS
Xi_0_484 OAI21_X1 $PINS ZN=n_0_468 A=n_0_497 B1=in_m[10] B2=n_0_495 VDD=VDD
+ VSS=VSS
Xi_0_483 NAND2_X1 $PINS ZN=n_0_467 A1=n_0_502 A2=n_0_500 VDD=VDD VSS=VSS
Xi_0_482 INV_X1 $PINS ZN=n_0_466 A=n_0_467 VDD=VDD VSS=VSS
Xi_0_481 AOI221_X1 $PINS ZN=n_0_465 A=in_m[13] B1=n_0_502 B2=in_m[11]
+ C1=n_0_468 C2=n_0_466 VDD=VDD VSS=VSS
Xi_0_480 NAND2_X1 $PINS ZN=n_0_464 A1=n_0_497 A2=in_m[6] VDD=VDD VSS=VSS
Xi_0_479 AOI211_X1 $PINS ZN=n_0_463 A=in_m[13] B=in_m[11] C1=n_0_496 C2=n_0_464
+ VDD=VDD VSS=VSS
Xi_0_478 AOI211_X1 $PINS ZN=n_0_462 A=in_m[12] B=n_0_463 C1=n_0_501 C2=in_m[10]
+ VDD=VDD VSS=VSS
Xi_0_477 AOI21_X1 $PINS ZN=n_0_461 A=in_m[6] B1=n_0_495 B2=in_m[4] VDD=VDD
+ VSS=VSS
Xi_0_476 OAI21_X1 $PINS ZN=n_0_460 A=n_0_492 B1=in_m[5] B2=n_0_490 VDD=VDD
+ VSS=VSS
Xi_0_475 NAND2_X1 $PINS ZN=n_0_459 A1=n_0_495 A2=n_0_494 VDD=VDD VSS=VSS
Xi_0_474 INV_X1 $PINS ZN=n_0_458 A=n_0_459 VDD=VDD VSS=VSS
Xi_0_473 NAND3_X1 $PINS ZN=n_0_457 A1=in_m[3] A2=n_0_458 A3=n_0_460 VDD=VDD
+ VSS=VSS
Xi_0_472 OAI21_X1 $PINS ZN=n_0_456 A=n_0_457 B1=n_0_493 B2=n_0_461 VDD=VDD
+ VSS=VSS
Xi_0_471 NAND2_X1 $PINS ZN=n_0_455 A1=n_0_502 A2=n_0_501 VDD=VDD VSS=VSS
Xi_0_470 INV_X1 $PINS ZN=n_0_454 A=n_0_455 VDD=VDD VSS=VSS
Xi_0_469 NOR2_X1 $PINS ZN=n_0_453 A1=in_m[12] A2=in_m[11] VDD=VDD VSS=VSS
Xi_0_468 NAND2_X1 $PINS ZN=n_0_452 A1=n_0_454 A2=n_0_453 VDD=VDD VSS=VSS
Xi_0_467 INV_X1 $PINS ZN=n_0_451 A=n_0_452 VDD=VDD VSS=VSS
Xi_0_466 NAND2_X1 $PINS ZN=n_0_450 A1=n_0_496 A2=n_0_451 VDD=VDD VSS=VSS
Xi_0_465 INV_X1 $PINS ZN=n_0_449 A=n_0_450 VDD=VDD VSS=VSS
Xi_0_464 NAND2_X1 $PINS ZN=n_0_448 A1=n_0_498 A2=n_0_497 VDD=VDD VSS=VSS
Xi_0_463 INV_X1 $PINS ZN=n_0_447 A=n_0_448 VDD=VDD VSS=VSS
Xi_0_462 NAND3_X1 $PINS ZN=n_0_446 A1=n_0_449 A2=n_0_447 A3=n_0_456 VDD=VDD
+ VSS=VSS
Xi_0_461 OAI21_X1 $PINS ZN=n_0_445 A=n_0_446 B1=n_0_465 B2=n_0_462 VDD=VDD
+ VSS=VSS
Xi_0_460 AOI22_X1 $PINS ZN=n_0_444 A1=in_m[14] A2=n_0_470 B1=n_0_469 B2=n_0_445
+ VDD=VDD VSS=VSS
Xi_0_459 OAI21_X1 $PINS ZN=n_0_443 A=n_0_509 B1=n_0_507 B2=n_0_483 VDD=VDD
+ VSS=VSS
Xi_0_458 NAND2_X1 $PINS ZN=n_0_442 A1=n_0_507 A2=in_m[16] VDD=VDD VSS=VSS
Xi_0_457 NAND2_X1 $PINS ZN=n_0_441 A1=n_0_506 A2=in_m[15] VDD=VDD VSS=VSS
Xi_0_456 AOI221_X1 $PINS ZN=n_0_440 A=n_0_478 B1=n_0_475 B2=n_0_441 C1=n_0_506
+ C2=n_0_442 VDD=VDD VSS=VSS
Xi_0_455 AOI21_X1 $PINS ZN=n_0_439 A=n_0_440 B1=n_0_482 B2=n_0_443 VDD=VDD
+ VSS=VSS
Xi_0_454 OAI21_X1 $PINS ZN=n_30 A=n_0_439 B1=n_0_472 B2=n_0_444 VDD=VDD VSS=VSS
Xi_0_453 AND2_X1 $PINS ZN=n_0_438 A1=n_0_477 A2=n_0_469 VDD=VDD VSS=VSS
Xi_0_452 AND2_X1 $PINS ZN=n_0_437 A1=n_0_473 A2=n_0_469 VDD=VDD VSS=VSS
Xi_0_451 NAND2_X1 $PINS ZN=n_0_436 A1=n_0_473 A2=n_0_438 VDD=VDD VSS=VSS
Xi_0_450 INV_X1 $PINS ZN=n_0_435 A=n_0_436 VDD=VDD VSS=VSS
Xi_0_449 NAND2_X1 $PINS ZN=n_0_434 A1=n_0_494 A2=in_m[5] VDD=VDD VSS=VSS
Xi_0_448 INV_X1 $PINS ZN=n_0_433 A=n_0_434 VDD=VDD VSS=VSS
Xi_0_447 NAND3_X1 $PINS ZN=n_0_432 A1=in_m[1] A2=n_0_458 A3=n_0_492 VDD=VDD
+ VSS=VSS
Xi_0_446 AOI211_X1 $PINS ZN=n_0_431 A=n_0_491 B=n_0_448 C1=n_0_434 C2=n_0_432
+ VDD=VDD VSS=VSS
Xi_0_445 NAND3_X1 $PINS ZN=n_0_430 A1=n_0_495 A2=in_m[4] A3=n_0_447 VDD=VDD
+ VSS=VSS
Xi_0_444 OAI33_X1 $PINS ZN=n_0_429 A1=in_m[5] A2=n_0_490 A3=n_0_430 B1=in_m[10]
+ B2=n_0_495 B3=n_0_493 VDD=VDD VSS=VSS
Xi_0_443 OR2_X1 $PINS ZN=n_0_428 A1=n_0_431 A2=n_0_429 VDD=VDD VSS=VSS
Xi_0_442 NAND2_X1 $PINS ZN=n_0_427 A1=n_0_499 A2=n_0_454 VDD=VDD VSS=VSS
Xi_0_441 INV_X1 $PINS ZN=n_0_426 A=n_0_427 VDD=VDD VSS=VSS
Xi_0_440 NAND2_X1 $PINS ZN=n_0_425 A1=n_0_500 A2=n_0_454 VDD=VDD VSS=VSS
Xi_0_439 INV_X1 $PINS ZN=n_0_424 A=n_0_425 VDD=VDD VSS=VSS
Xi_0_438 NAND2_X1 $PINS ZN=n_0_423 A1=n_0_498 A2=in_m[9] VDD=VDD VSS=VSS
Xi_0_437 INV_X1 $PINS ZN=n_0_422 A=n_0_423 VDD=VDD VSS=VSS
Xi_0_436 NAND3_X1 $PINS ZN=n_0_421 A1=in_m[7] A2=n_0_422 A3=n_0_424 VDD=VDD
+ VSS=VSS
Xi_0_435 AOI211_X1 $PINS ZN=n_0_420 A=n_0_464 B=n_0_452 C1=n_0_496 C2=n_0_430
+ VDD=VDD VSS=VSS
Xi_0_434 AOI22_X1 $PINS ZN=n_0_419 A1=in_m[8] A2=n_0_426 B1=n_0_501 B2=in_m[12]
+ VDD=VDD VSS=VSS
Xi_0_433 OAI21_X1 $PINS ZN=n_0_418 A=n_0_421 B1=n_0_498 B2=n_0_419 VDD=VDD
+ VSS=VSS
Xi_0_432 AOI211_X1 $PINS ZN=n_0_417 A=n_0_420 B=n_0_418 C1=n_0_449 C2=n_0_428
+ VDD=VDD VSS=VSS
Xi_0_431 NAND2_X1 $PINS ZN=n_0_416 A1=n_0_504 A2=n_0_471 VDD=VDD VSS=VSS
Xi_0_430 INV_X1 $PINS ZN=n_0_415 A=n_0_416 VDD=VDD VSS=VSS
Xi_0_429 OAI33_X1 $PINS ZN=n_0_414 A1=n_0_497 A2=n_0_436 A3=in_m[12]
+ B1=in_m[16] B2=n_0_472 B3=n_0_501 VDD=VDD VSS=VSS
Xi_0_428 NAND3_X1 $PINS ZN=n_0_413 A1=n_0_502 A2=in_m[11] A3=n_0_414 VDD=VDD
+ VSS=VSS
Xi_0_427 NOR3_X1 $PINS ZN=n_0_412 A1=n_0_504 A2=n_0_478 A3=n_0_476 VDD=VDD
+ VSS=VSS
Xi_0_426 NAND2_X1 $PINS ZN=n_0_411 A1=n_0_503 A2=n_0_471 VDD=VDD VSS=VSS
Xi_0_425 INV_X1 $PINS ZN=n_0_410 A=n_0_411 VDD=VDD VSS=VSS
Xi_0_424 AOI21_X1 $PINS ZN=n_0_409 A=n_0_412 B1=in_m[12] B2=n_0_410 VDD=VDD
+ VSS=VSS
Xi_0_423 NAND2_X1 $PINS ZN=n_0_408 A1=n_0_504 A2=in_m[15] VDD=VDD VSS=VSS
Xi_0_422 NAND3_X1 $PINS ZN=n_0_407 A1=in_m[13] A2=n_0_474 A3=n_0_477 VDD=VDD
+ VSS=VSS
Xi_0_421 OAI33_X1 $PINS ZN=n_0_406 A1=in_m[19] A2=n_0_504 A3=n_0_506
+ B1=in_m[20] B2=n_0_505 B3=n_0_441 VDD=VDD VSS=VSS
Xi_0_420 NAND2_X1 $PINS ZN=n_0_405 A1=in_m[21] A2=n_0_484 VDD=VDD VSS=VSS
Xi_0_419 INV_X1 $PINS ZN=n_0_404 A=n_0_405 VDD=VDD VSS=VSS
Xi_0_418 AOI21_X1 $PINS ZN=n_0_403 A=n_0_483 B1=n_0_509 B2=in_m[18] VDD=VDD
+ VSS=VSS
Xi_0_417 OAI21_X1 $PINS ZN=n_0_402 A=n_0_509 B1=in_m[20] B2=n_0_505 VDD=VDD
+ VSS=VSS
Xi_0_416 NAND3_X1 $PINS ZN=n_0_401 A1=in_m[19] A2=n_0_484 A3=n_0_402 VDD=VDD
+ VSS=VSS
Xi_0_415 OAI21_X1 $PINS ZN=n_0_400 A=n_0_401 B1=n_0_508 B2=n_0_403 VDD=VDD
+ VSS=VSS
Xi_0_414 AOI21_X1 $PINS ZN=n_0_399 A=n_0_400 B1=n_0_479 B2=n_0_406 VDD=VDD
+ VSS=VSS
Xi_0_413 OAI221_X1 $PINS ZN=n_0_398 A=n_0_399 B1=n_0_408 B2=n_0_407 C1=n_0_502
+ C2=n_0_409 VDD=VDD VSS=VSS
Xi_0_412 INV_X1 $PINS ZN=n_0_397 A=n_0_398 VDD=VDD VSS=VSS
Xi_0_411 OAI211_X1 $PINS ZN=n_29 A=n_0_413 B=n_0_397 C1=n_0_436 C2=n_0_417
+ VDD=VDD VSS=VSS
Xi_0_410 NAND4_X1 $PINS ZN=n_0_396 A1=n_0_497 A2=n_0_493 A3=n_0_492 A4=in_m[0]
+ VDD=VDD VSS=VSS
Xi_0_409 AOI211_X1 $PINS ZN=n_0_395 A=in_m[7] B=n_0_491 C1=n_0_494 C2=n_0_396
+ VDD=VDD VSS=VSS
Xi_0_408 NAND2_X1 $PINS ZN=n_0_394 A1=n_0_494 A2=n_0_493 VDD=VDD VSS=VSS
Xi_0_407 INV_X1 $PINS ZN=n_0_393 A=n_0_394 VDD=VDD VSS=VSS
Xi_0_406 NAND3_X1 $PINS ZN=n_0_392 A1=n_0_498 A2=in_m[1] A3=n_0_393 VDD=VDD
+ VSS=VSS
Xi_0_405 AOI21_X1 $PINS ZN=n_0_391 A=n_0_492 B1=n_0_495 B2=n_0_392 VDD=VDD
+ VSS=VSS
Xi_0_404 AOI22_X1 $PINS ZN=n_0_390 A1=n_0_498 A2=n_0_395 B1=n_0_497 B2=n_0_391
+ VDD=VDD VSS=VSS
Xi_0_403 NAND3_X1 $PINS ZN=n_0_389 A1=in_m[6] A2=n_0_422 A3=n_0_426 VDD=VDD
+ VSS=VSS
Xi_0_402 NAND3_X1 $PINS ZN=n_0_388 A1=n_0_499 A2=in_m[2] A3=n_0_458 VDD=VDD
+ VSS=VSS
Xi_0_401 AOI21_X1 $PINS ZN=n_0_387 A=n_0_493 B1=n_0_496 B2=n_0_388 VDD=VDD
+ VSS=VSS
Xi_0_400 NAND3_X1 $PINS ZN=n_0_386 A1=n_0_447 A2=n_0_424 A3=n_0_387 VDD=VDD
+ VSS=VSS
Xi_0_399 OAI211_X1 $PINS ZN=n_0_385 A=n_0_389 B=n_0_386 C1=n_0_450 C2=n_0_390
+ VDD=VDD VSS=VSS
Xi_0_398 NAND2_X1 $PINS ZN=n_0_384 A1=in_m[12] A2=n_0_454 VDD=VDD VSS=VSS
Xi_0_397 INV_X1 $PINS ZN=n_0_383 A=n_0_384 VDD=VDD VSS=VSS
Xi_0_396 NOR3_X1 $PINS ZN=n_0_382 A1=n_0_497 A2=n_0_416 A3=n_0_384 VDD=VDD
+ VSS=VSS
Xi_0_395 OAI21_X1 $PINS ZN=n_0_381 A=n_0_484 B1=n_0_504 B2=n_0_478 VDD=VDD
+ VSS=VSS
Xi_0_394 AOI221_X1 $PINS ZN=n_0_380 A=n_0_382 B1=in_m[19] B2=n_0_381 C1=n_0_435
+ C2=n_0_385 VDD=VDD VSS=VSS
Xi_0_393 NAND2_X1 $PINS ZN=n_0_379 A1=n_0_479 A2=n_0_437 VDD=VDD VSS=VSS
Xi_0_392 NAND3_X1 $PINS ZN=n_0_378 A1=n_0_479 A2=n_0_437 A3=in_m[8] VDD=VDD
+ VSS=VSS
Xi_0_391 NAND2_X1 $PINS ZN=n_0_377 A1=n_0_474 A2=n_0_438 VDD=VDD VSS=VSS
Xi_0_390 NOR2_X1 $PINS ZN=n_0_376 A1=n_0_502 A2=n_0_377 VDD=VDD VSS=VSS
Xi_0_389 NOR4_X1 $PINS ZN=n_0_375 A1=in_m[20] A2=n_0_378 A3=in_m[12]
+ A4=in_m[13] VDD=VDD VSS=VSS
Xi_0_388 OAI21_X1 $PINS ZN=n_0_374 A=in_m[11] B1=n_0_376 B2=n_0_375 VDD=VDD
+ VSS=VSS
Xi_0_387 NAND2_X1 $PINS ZN=n_0_373 A1=n_0_508 A2=n_0_507 VDD=VDD VSS=VSS
Xi_0_386 OAI21_X1 $PINS ZN=n_0_372 A=n_0_509 B1=n_0_503 B2=n_0_373 VDD=VDD
+ VSS=VSS
Xi_0_385 NAND2_X1 $PINS ZN=n_0_371 A1=n_0_506 A2=n_0_505 VDD=VDD VSS=VSS
Xi_0_384 INV_X1 $PINS ZN=n_0_370 A=n_0_371 VDD=VDD VSS=VSS
Xi_0_383 OAI33_X1 $PINS ZN=n_0_369 A1=n_0_476 A2=n_0_408 A3=n_0_500 B1=n_0_501
+ B2=n_0_371 B3=n_0_504 VDD=VDD VSS=VSS
Xi_0_382 NAND2_X1 $PINS ZN=n_0_368 A1=n_0_508 A2=n_0_369 VDD=VDD VSS=VSS
Xi_0_381 AOI21_X1 $PINS ZN=n_0_367 A=in_m[20] B1=in_m[14] B2=n_0_474 VDD=VDD
+ VSS=VSS
Xi_0_380 OAI21_X1 $PINS ZN=n_0_366 A=n_0_368 B1=n_0_505 B2=n_0_367 VDD=VDD
+ VSS=VSS
Xi_0_379 NAND3_X1 $PINS ZN=n_0_365 A1=in_m[18] A2=n_0_484 A3=n_0_372 VDD=VDD
+ VSS=VSS
Xi_0_378 NAND2_X1 $PINS ZN=n_0_364 A1=in_m[7] A2=n_0_435 VDD=VDD VSS=VSS
Xi_0_377 NAND2_X1 $PINS ZN=n_0_363 A1=n_0_499 A2=n_0_466 VDD=VDD VSS=VSS
Xi_0_376 OR2_X1 $PINS ZN=n_0_362 A1=n_0_364 A2=n_0_363 VDD=VDD VSS=VSS
Xi_0_375 NAND2_X1 $PINS ZN=n_0_361 A1=n_0_502 A2=in_m[13] VDD=VDD VSS=VSS
Xi_0_374 INV_X1 $PINS ZN=n_0_360 A=n_0_361 VDD=VDD VSS=VSS
Xi_0_373 OAI21_X1 $PINS ZN=n_0_359 A=n_0_362 B1=n_0_411 B2=n_0_361 VDD=VDD
+ VSS=VSS
Xi_0_372 AOI22_X1 $PINS ZN=n_0_358 A1=n_0_479 A2=n_0_366 B1=in_m[10] B2=n_0_359
+ VDD=VDD VSS=VSS
Xi_0_371 NAND4_X1 $PINS ZN=n_28 A1=n_0_380 A2=n_0_374 A3=n_0_365 A4=n_0_358
+ VDD=VDD VSS=VSS
Xi_0_370 NAND2_X1 $PINS ZN=n_0_357 A1=n_0_475 A2=n_0_438 VDD=VDD VSS=VSS
Xi_0_369 NOR2_X1 $PINS ZN=n_0_356 A1=in_m[21] A2=n_0_373 VDD=VDD VSS=VSS
Xi_0_368 NAND2_X1 $PINS ZN=n_0_355 A1=in_m[18] A2=n_0_356 VDD=VDD VSS=VSS
Xi_0_367 OAI21_X1 $PINS ZN=n_0_354 A=n_0_355 B1=n_0_498 B2=n_0_357 VDD=VDD
+ VSS=VSS
Xi_0_366 NOR2_X2 $PINS ZN=n_0_353 A1=n_0_507 A2=n_0_478 VDD=VDD VSS=VSS
Xi_0_365 NAND2_X1 $PINS ZN=n_0_352 A1=in_m[20] A2=n_0_479 VDD=VDD VSS=VSS
Xi_0_364 INV_X1 $PINS ZN=n_0_351 A=n_0_352 VDD=VDD VSS=VSS
Xi_0_363 OAI33_X1 $PINS ZN=n_0_350 A1=n_0_499 A2=n_0_408 A3=n_0_478 B1=n_0_500
+ B2=n_0_480 B3=n_0_442 VDD=VDD VSS=VSS
Xi_0_362 AOI21_X1 $PINS ZN=n_0_349 A=n_0_505 B1=n_0_407 B2=n_0_405 VDD=VDD
+ VSS=VSS
Xi_0_361 NAND2_X1 $PINS ZN=n_0_348 A1=in_m[11] A2=n_0_424 VDD=VDD VSS=VSS
Xi_0_360 INV_X1 $PINS ZN=n_0_347 A=n_0_348 VDD=VDD VSS=VSS
Xi_0_359 AOI221_X1 $PINS ZN=n_0_346 A=n_0_349 B1=in_m[14] B2=n_0_354
+ C1=in_m[16] C2=n_0_351 VDD=VDD VSS=VSS
Xi_0_358 NAND3_X1 $PINS ZN=n_0_345 A1=in_m[8] A2=n_0_410 A3=n_0_383 VDD=VDD
+ VSS=VSS
Xi_0_357 AOI222_X1 $PINS ZN=n_0_344 A1=in_m[15] A2=n_0_353 B1=in_m[18]
+ B2=n_0_483 C1=n_0_370 C2=n_0_350 VDD=VDD VSS=VSS
Xi_0_356 OAI33_X1 $PINS ZN=n_0_343 A1=n_0_416 A2=n_0_348 A3=n_0_495 B1=n_0_377
+ B2=n_0_361 B3=n_0_497 VDD=VDD VSS=VSS
Xi_0_355 INV_X1 $PINS ZN=n_0_342 A=n_0_343 VDD=VDD VSS=VSS
Xi_0_354 AND4_X1 $PINS ZN=n_0_341 A1=n_0_344 A2=n_0_342 A3=n_0_345 A4=n_0_346
+ VDD=VDD VSS=VSS
Xi_0_353 NOR3_X1 $PINS ZN=n_0_340 A1=in_m[9] A2=in_m[7] A3=n_0_450 VDD=VDD
+ VSS=VSS
Xi_0_352 NAND2_X1 $PINS ZN=n_0_339 A1=in_m[2] A2=n_0_340 VDD=VDD VSS=VSS
Xi_0_351 NAND2_X1 $PINS ZN=n_0_338 A1=n_0_501 A2=n_0_453 VDD=VDD VSS=VSS
Xi_0_350 OAI21_X1 $PINS ZN=n_0_337 A=n_0_339 B1=n_0_498 B2=n_0_338 VDD=VDD
+ VSS=VSS
Xi_0_349 OAI33_X1 $PINS ZN=n_0_336 A1=n_0_489 A2=n_0_459 A3=n_0_450 B1=in_m[11]
+ B2=n_0_467 B3=n_0_497 VDD=VDD VSS=VSS
Xi_0_348 AND2_X1 $PINS ZN=n_0_335 A1=in_m[5] A2=n_0_336 VDD=VDD VSS=VSS
Xi_0_347 NAND2_X1 $PINS ZN=n_0_334 A1=in_m[8] A2=n_0_447 VDD=VDD VSS=VSS
Xi_0_346 INV_X1 $PINS ZN=n_0_333 A=n_0_334 VDD=VDD VSS=VSS
Xi_0_345 NAND2_X1 $PINS ZN=n_0_332 A1=in_m[0] A2=n_0_451 VDD=VDD VSS=VSS
Xi_0_344 OAI33_X1 $PINS ZN=n_0_331 A1=n_0_492 A2=n_0_427 A3=n_0_334 B1=n_0_430
+ B2=n_0_394 B3=n_0_332 VDD=VDD VSS=VSS
Xi_0_343 NAND2_X1 $PINS ZN=n_0_330 A1=n_0_496 A2=n_0_447 VDD=VDD VSS=VSS
Xi_0_342 INV_X1 $PINS ZN=n_0_329 A=n_0_330 VDD=VDD VSS=VSS
Xi_0_341 AOI221_X1 $PINS ZN=n_0_328 A=n_0_331 B1=n_0_498 B2=n_0_335 C1=in_m[6]
+ C2=n_0_337 VDD=VDD VSS=VSS
Xi_0_340 NOR2_X1 $PINS ZN=n_0_327 A1=n_0_364 A2=n_0_330 VDD=VDD VSS=VSS
Xi_0_339 NAND2_X1 $PINS ZN=n_0_326 A1=n_0_424 A2=n_0_327 VDD=VDD VSS=VSS
Xi_0_338 OAI221_X1 $PINS ZN=n_27 A=n_0_341 B1=n_0_491 B2=n_0_326 C1=n_0_436
+ C2=n_0_328 VDD=VDD VSS=VSS
Xi_0_337 NOR4_X1 $PINS ZN=n_0_325 A1=n_0_427 A2=n_0_330 A3=n_0_490 A4=n_0_364
+ VDD=VDD VSS=VSS
Xi_0_336 NAND2_X1 $PINS ZN=n_0_324 A1=n_0_506 A2=n_0_481 VDD=VDD VSS=VSS
Xi_0_335 NAND3_X1 $PINS ZN=n_0_323 A1=n_0_506 A2=n_0_481 A3=n_0_412 VDD=VDD
+ VSS=VSS
Xi_0_334 INV_X1 $PINS ZN=n_0_322 A=n_0_323 VDD=VDD VSS=VSS
Xi_0_333 NAND2_X1 $PINS ZN=n_0_321 A1=in_m[0] A2=n_0_435 VDD=VDD VSS=VSS
Xi_0_332 INV_X1 $PINS ZN=n_0_320 A=n_0_321 VDD=VDD VSS=VSS
Xi_0_331 OAI22_X1 $PINS ZN=n_0_319 A1=n_0_497 A2=n_0_436 B1=n_0_507 B2=n_0_478
+ VDD=VDD VSS=VSS
Xi_0_330 OAI21_X1 $PINS ZN=n_0_318 A=n_0_352 B1=n_0_498 B2=n_0_416 VDD=VDD
+ VSS=VSS
Xi_0_329 AOI22_X1 $PINS ZN=n_0_317 A1=in_m[14] A2=n_0_319 B1=in_m[15]
+ B2=n_0_318 VDD=VDD VSS=VSS
Xi_0_328 NAND2_X1 $PINS ZN=n_0_316 A1=in_m[10] A2=n_0_451 VDD=VDD VSS=VSS
Xi_0_327 INV_X1 $PINS ZN=n_0_315 A=n_0_316 VDD=VDD VSS=VSS
Xi_0_326 NOR4_X1 $PINS ZN=n_0_314 A1=n_0_489 A2=n_0_425 A3=in_m[7] A4=n_0_494
+ VDD=VDD VSS=VSS
Xi_0_325 OAI33_X1 $PINS ZN=n_0_313 A1=n_0_363 A2=n_0_334 A3=n_0_491 B1=n_0_423
+ B2=n_0_338 B3=n_0_492 VDD=VDD VSS=VSS
Xi_0_324 AOI21_X1 $PINS ZN=n_0_312 A=n_0_313 B1=n_0_329 B2=n_0_314 VDD=VDD
+ VSS=VSS
Xi_0_323 NAND3_X1 $PINS ZN=n_0_311 A1=in_m[17] A2=n_0_477 A3=n_0_474 VDD=VDD
+ VSS=VSS
Xi_0_322 INV_X1 $PINS ZN=n_0_310 A=n_0_311 VDD=VDD VSS=VSS
Xi_0_321 NOR2_X2 $PINS ZN=n_0_309 A1=n_0_483 A2=n_0_355 VDD=VDD VSS=VSS
Xi_0_320 INV_X1 $PINS ZN=n_0_308 A=n_0_309 VDD=VDD VSS=VSS
Xi_0_319 OAI33_X1 $PINS ZN=n_0_307 A1=n_0_384 A2=n_0_377 A3=n_0_495 B1=n_0_361
+ B2=n_0_357 B3=n_0_496 VDD=VDD VSS=VSS
Xi_0_318 AOI221_X1 $PINS ZN=n_0_306 A=n_0_307 B1=in_m[12] B2=n_0_310
+ C1=in_m[13] C2=n_0_309 VDD=VDD VSS=VSS
Xi_0_317 OAI33_X1 $PINS ZN=n_0_305 A1=n_0_411 A2=n_0_348 A3=n_0_494 B1=n_0_416
+ B2=n_0_316 B3=n_0_493 VDD=VDD VSS=VSS
Xi_0_316 OAI222_X1 $PINS ZN=n_0_304 A1=n_0_499 A2=n_0_323 B1=n_0_504 B2=n_0_405
+ C1=n_0_505 C2=n_0_484 VDD=VDD VSS=VSS
Xi_0_315 NAND3_X1 $PINS ZN=n_0_303 A1=in_m[0] A2=n_0_340 A3=n_0_433 VDD=VDD
+ VSS=VSS
Xi_0_314 AOI21_X1 $PINS ZN=n_0_302 A=n_0_436 B1=n_0_312 B2=n_0_303 VDD=VDD
+ VSS=VSS
Xi_0_313 NOR4_X1 $PINS ZN=n_0_301 A1=n_0_305 A2=n_0_304 A3=n_0_325 A4=n_0_302
+ VDD=VDD VSS=VSS
Xi_0_312 NAND3_X1 $PINS ZN=n_26 A1=n_0_306 A2=n_0_301 A3=n_0_317 VDD=VDD
+ VSS=VSS
Xi_0_311 OAI21_X1 $PINS ZN=n_0_300 A=n_0_405 B1=n_0_497 B2=n_0_416 VDD=VDD
+ VSS=VSS
Xi_0_310 NOR3_X1 $PINS ZN=n_0_299 A1=n_0_493 A2=n_0_348 A3=n_0_377 VDD=VDD
+ VSS=VSS
Xi_0_309 NAND3_X1 $PINS ZN=n_0_298 A1=n_0_426 A2=n_0_329 A3=n_0_495 VDD=VDD
+ VSS=VSS
Xi_0_308 NAND2_X1 $PINS ZN=n_0_297 A1=n_0_451 A2=n_0_422 VDD=VDD VSS=VSS
Xi_0_307 INV_X1 $PINS ZN=n_0_296 A=n_0_297 VDD=VDD VSS=VSS
Xi_0_306 AOI21_X1 $PINS ZN=n_0_295 A=n_0_502 B1=n_0_378 B2=n_0_352 VDD=VDD
+ VSS=VSS
Xi_0_305 NAND2_X1 $PINS ZN=n_0_294 A1=in_m[13] A2=n_0_353 VDD=VDD VSS=VSS
Xi_0_304 AND2_X1 $PINS ZN=n_0_293 A1=n_0_473 A2=n_0_356 VDD=VDD VSS=VSS
Xi_0_303 AOI21_X1 $PINS ZN=n_0_292 A=n_0_483 B1=in_m[10] B2=n_0_293 VDD=VDD
+ VSS=VSS
Xi_0_302 INV_X1 $PINS ZN=n_0_291 A=n_0_292 VDD=VDD VSS=VSS
Xi_0_301 NAND2_X1 $PINS ZN=n_0_290 A1=n_0_438 A2=n_0_370 VDD=VDD VSS=VSS
Xi_0_300 NOR4_X1 $PINS ZN=n_0_289 A1=n_0_338 A2=n_0_334 A3=n_0_490 A4=n_0_436
+ VDD=VDD VSS=VSS
Xi_0_299 OAI33_X1 $PINS ZN=n_0_288 A1=n_0_416 A2=n_0_297 A3=n_0_491 B1=n_0_362
+ B2=n_0_330 B3=n_0_489 VDD=VDD VSS=VSS
Xi_0_298 OAI33_X1 $PINS ZN=n_0_287 A1=n_0_361 A2=n_0_290 A3=n_0_495 B1=n_0_384
+ B2=n_0_357 B3=n_0_494 VDD=VDD VSS=VSS
Xi_0_297 AOI211_X1 $PINS ZN=n_0_286 A=n_0_287 B=n_0_299 C1=in_m[16] C2=n_0_291
+ VDD=VDD VSS=VSS
Xi_0_296 OAI33_X1 $PINS ZN=n_0_285 A1=n_0_321 A2=n_0_298 A3=n_0_494 B1=n_0_411
+ B2=n_0_316 B3=n_0_492 VDD=VDD VSS=VSS
Xi_0_295 AOI21_X1 $PINS ZN=n_0_284 A=n_0_289 B1=in_m[11] B2=n_0_310 VDD=VDD
+ VSS=VSS
Xi_0_294 OAI211_X1 $PINS ZN=n_0_283 A=n_0_294 B=n_0_284 C1=n_0_500 C2=n_0_308
+ VDD=VDD VSS=VSS
Xi_0_293 AOI211_X1 $PINS ZN=n_0_282 A=n_0_285 B=n_0_283 C1=in_m[15] C2=n_0_300
+ VDD=VDD VSS=VSS
Xi_0_292 NAND2_X1 $PINS ZN=n_0_281 A1=n_0_286 A2=n_0_282 VDD=VDD VSS=VSS
Xi_0_291 OR3_X1 $PINS ZN=n_25 A1=n_0_295 A2=n_0_281 A3=n_0_288 VDD=VDD VSS=VSS
Xi_0_290 NAND2_X1 $PINS ZN=n_0_280 A1=in_m[6] A2=n_0_360 VDD=VDD VSS=VSS
Xi_0_289 AOI21_X1 $PINS ZN=n_0_279 A=n_0_502 B1=n_0_405 B2=n_0_364 VDD=VDD
+ VSS=VSS
Xi_0_288 NAND3_X1 $PINS ZN=n_0_278 A1=n_0_504 A2=in_m[15] A3=n_0_293 VDD=VDD
+ VSS=VSS
Xi_0_287 NAND4_X1 $PINS ZN=n_0_277 A1=in_m[1] A2=n_0_415 A3=n_0_447 A4=n_0_451
+ VDD=VDD VSS=VSS
Xi_0_286 AOI21_X1 $PINS ZN=n_0_276 A=n_0_496 B1=n_0_278 B2=n_0_277 VDD=VDD
+ VSS=VSS
Xi_0_285 INV_X1 $PINS ZN=n_0_275 A=n_0_276 VDD=VDD VSS=VSS
Xi_0_284 OAI33_X1 $PINS ZN=n_0_274 A1=n_0_490 A2=n_0_297 A3=n_0_411 B1=n_0_491
+ B2=n_0_377 B3=n_0_316 VDD=VDD VSS=VSS
Xi_0_283 NOR3_X1 $PINS ZN=n_0_273 A1=n_0_357 A2=n_0_348 A3=n_0_492 VDD=VDD
+ VSS=VSS
Xi_0_282 NOR3_X1 $PINS ZN=n_0_272 A1=n_0_279 A2=n_0_273 A3=n_0_274 VDD=VDD
+ VSS=VSS
Xi_0_281 NAND4_X1 $PINS ZN=n_0_271 A1=n_0_501 A2=n_0_453 A3=n_0_327 A4=in_m[0]
+ VDD=VDD VSS=VSS
Xi_0_280 AOI222_X1 $PINS ZN=n_0_270 A1=in_m[13] A2=n_0_351 B1=in_m[10]
+ B2=n_0_310 C1=in_m[15] C2=n_0_483 VDD=VDD VSS=VSS
Xi_0_279 AOI22_X1 $PINS ZN=n_0_269 A1=in_m[12] A2=n_0_353 B1=in_m[11]
+ B2=n_0_309 VDD=VDD VSS=VSS
Xi_0_278 OAI211_X1 $PINS ZN=n_0_268 A=n_0_269 B=n_0_270 C1=n_0_379 C2=n_0_280
+ VDD=VDD VSS=VSS
Xi_0_277 NOR3_X1 $PINS ZN=n_0_267 A1=n_0_384 A2=n_0_290 A3=n_0_493 VDD=VDD
+ VSS=VSS
Xi_0_276 AOI211_X1 $PINS ZN=n_0_266 A=n_0_267 B=n_0_268 C1=in_m[9] C2=n_0_322
+ VDD=VDD VSS=VSS
Xi_0_275 NAND4_X1 $PINS ZN=n_24 A1=n_0_272 A2=n_0_271 A3=n_0_275 A4=n_0_266
+ VDD=VDD VSS=VSS
Xi_0_274 NOR3_X1 $PINS ZN=n_0_265 A1=n_0_491 A2=n_0_348 A3=n_0_290 VDD=VDD
+ VSS=VSS
Xi_0_273 NOR2_X1 $PINS ZN=n_0_264 A1=n_0_483 A2=n_0_278 VDD=VDD VSS=VSS
Xi_0_272 INV_X1 $PINS ZN=n_0_263 A=n_0_264 VDD=VDD VSS=VSS
Xi_0_271 OAI33_X1 $PINS ZN=n_0_262 A1=n_0_489 A2=n_0_297 A3=n_0_377 B1=n_0_490
+ B2=n_0_316 B3=n_0_357 VDD=VDD VSS=VSS
Xi_0_270 AOI211_X1 $PINS ZN=n_0_261 A=n_0_265 B=n_0_262 C1=in_m[7] C2=n_0_264
+ VDD=VDD VSS=VSS
Xi_0_269 NAND2_X1 $PINS ZN=n_0_260 A1=n_0_437 A2=n_0_356 VDD=VDD VSS=VSS
Xi_0_268 OAI21_X1 $PINS ZN=n_0_259 A=n_0_484 B1=n_0_494 B2=n_0_260 VDD=VDD
+ VSS=VSS
Xi_0_267 AOI22_X1 $PINS ZN=n_0_258 A1=in_m[8] A2=n_0_322 B1=in_m[14] B2=n_0_259
+ VDD=VDD VSS=VSS
Xi_0_266 NAND2_X1 $PINS ZN=n_0_257 A1=n_0_481 A2=n_0_437 VDD=VDD VSS=VSS
Xi_0_265 OAI33_X1 $PINS ZN=n_0_256 A1=n_0_493 A2=n_0_361 A3=n_0_257 B1=n_0_492
+ B2=n_0_384 B3=n_0_379 VDD=VDD VSS=VSS
Xi_0_264 AOI221_X1 $PINS ZN=n_0_255 A=n_0_256 B1=in_m[11] B2=n_0_353 C1=in_m[9]
+ C2=n_0_310 VDD=VDD VSS=VSS
Xi_0_263 NOR3_X1 $PINS ZN=n_0_254 A1=n_0_334 A2=n_0_332 A3=n_0_411 VDD=VDD
+ VSS=VSS
Xi_0_262 OAI22_X1 $PINS ZN=n_0_253 A1=n_0_500 A2=n_0_352 B1=n_0_501 B2=n_0_405
+ VDD=VDD VSS=VSS
Xi_0_261 AOI211_X1 $PINS ZN=n_0_252 A=n_0_253 B=n_0_254 C1=in_m[10] C2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_260 NAND4_X1 $PINS ZN=n_23 A1=n_0_255 A2=n_0_252 A3=n_0_258 A4=n_0_261
+ VDD=VDD VSS=VSS
Xi_0_259 OAI33_X1 $PINS ZN=n_0_251 A1=n_0_492 A2=n_0_361 A3=n_0_260 B1=n_0_490
+ B2=n_0_348 B3=n_0_379 VDD=VDD VSS=VSS
Xi_0_258 AOI222_X1 $PINS ZN=n_0_250 A1=in_m[13] A2=n_0_483 B1=in_m[12]
+ B2=n_0_404 C1=in_m[11] C2=n_0_351 VDD=VDD VSS=VSS
Xi_0_257 NOR3_X1 $PINS ZN=n_0_249 A1=n_0_491 A2=n_0_384 A3=n_0_257 VDD=VDD
+ VSS=VSS
Xi_0_256 AOI21_X1 $PINS ZN=n_0_248 A=n_0_249 B1=in_m[10] B2=n_0_353 VDD=VDD
+ VSS=VSS
Xi_0_255 OAI211_X1 $PINS ZN=n_0_247 A=n_0_250 B=n_0_248 C1=n_0_496 C2=n_0_311
+ VDD=VDD VSS=VSS
Xi_0_254 AOI211_X1 $PINS ZN=n_0_246 A=n_0_251 B=n_0_247 C1=in_m[9] C2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_253 NOR2_X1 $PINS ZN=n_0_245 A1=n_0_502 A2=n_0_436 VDD=VDD VSS=VSS
Xi_0_252 AOI22_X1 $PINS ZN=n_0_244 A1=in_m[7] A2=n_0_322 B1=in_m[5] B2=n_0_245
+ VDD=VDD VSS=VSS
Xi_0_251 NAND4_X1 $PINS ZN=n_0_243 A1=n_0_475 A2=n_0_438 A3=in_m[0] A4=n_0_296
+ VDD=VDD VSS=VSS
Xi_0_250 NOR3_X1 $PINS ZN=n_0_242 A1=n_0_489 A2=n_0_316 A3=n_0_290 VDD=VDD
+ VSS=VSS
Xi_0_249 AOI21_X1 $PINS ZN=n_0_241 A=n_0_242 B1=in_m[6] B2=n_0_264 VDD=VDD
+ VSS=VSS
Xi_0_248 NAND4_X1 $PINS ZN=n_22 A1=n_0_246 A2=n_0_244 A3=n_0_243 A4=n_0_241
+ VDD=VDD VSS=VSS
Xi_0_247 NOR2_X1 $PINS ZN=n_0_240 A1=n_0_436 A2=n_0_361 VDD=VDD VSS=VSS
Xi_0_246 OAI21_X1 $PINS ZN=n_0_239 A=n_0_352 B1=n_0_379 B2=n_0_332 VDD=VDD
+ VSS=VSS
Xi_0_245 AOI22_X1 $PINS ZN=n_0_238 A1=in_m[3] A2=n_0_240 B1=in_m[10] B2=n_0_239
+ VDD=VDD VSS=VSS
Xi_0_244 NAND2_X1 $PINS ZN=n_0_237 A1=in_m[6] A2=n_0_322 VDD=VDD VSS=VSS
Xi_0_243 OAI33_X1 $PINS ZN=n_0_236 A1=n_0_348 A2=n_0_257 A3=n_0_489 B1=n_0_384
+ B2=n_0_260 B3=n_0_490 VDD=VDD VSS=VSS
Xi_0_242 AOI221_X1 $PINS ZN=n_0_235 A=n_0_236 B1=in_m[7] B2=n_0_310 C1=in_m[8]
+ C2=n_0_309 VDD=VDD VSS=VSS
Xi_0_241 AOI22_X1 $PINS ZN=n_0_234 A1=in_m[11] A2=n_0_404 B1=in_m[9] B2=n_0_353
+ VDD=VDD VSS=VSS
Xi_0_240 AOI22_X1 $PINS ZN=n_0_233 A1=in_m[5] A2=n_0_264 B1=in_m[4] B2=n_0_245
+ VDD=VDD VSS=VSS
Xi_0_239 OAI211_X1 $PINS ZN=n_0_232 A=n_0_234 B=n_0_233 C1=n_0_500 C2=n_0_484
+ VDD=VDD VSS=VSS
Xi_0_238 INV_X1 $PINS ZN=n_0_231 A=n_0_232 VDD=VDD VSS=VSS
Xi_0_237 NAND4_X1 $PINS ZN=n_21 A1=n_0_235 A2=n_0_231 A3=n_0_237 A4=n_0_238
+ VDD=VDD VSS=VSS
Xi_0_236 AOI22_X1 $PINS ZN=n_0_230 A1=in_m[10] A2=n_0_404 B1=in_m[11]
+ B2=n_0_483 VDD=VDD VSS=VSS
Xi_0_235 AOI222_X1 $PINS ZN=n_0_229 A1=in_m[6] A2=n_0_310 B1=in_m[8] B2=n_0_353
+ C1=in_m[5] C2=n_0_322 VDD=VDD VSS=VSS
Xi_0_234 OAI221_X1 $PINS ZN=n_0_228 A=n_0_230 B1=n_0_497 B2=n_0_352 C1=n_0_492
+ C2=n_0_263 VDD=VDD VSS=VSS
Xi_0_233 OAI222_X1 $PINS ZN=n_0_227 A1=n_0_502 A2=n_0_491 B1=n_0_490 B2=n_0_361
+ C1=n_0_489 C2=n_0_384 VDD=VDD VSS=VSS
Xi_0_232 NOR2_X1 $PINS ZN=n_0_226 A1=n_0_348 A2=n_0_260 VDD=VDD VSS=VSS
Xi_0_231 AOI221_X1 $PINS ZN=n_0_225 A=n_0_228 B1=n_0_435 B2=n_0_227 C1=in_m[0]
+ C2=n_0_226 VDD=VDD VSS=VSS
Xi_0_230 OAI211_X1 $PINS ZN=n_20 A=n_0_225 B=n_0_229 C1=n_0_495 C2=n_0_308
+ VDD=VDD VSS=VSS
Xi_0_229 AOI22_X1 $PINS ZN=n_0_224 A1=in_m[7] A2=n_0_353 B1=in_m[6] B2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_228 AOI222_X1 $PINS ZN=n_0_223 A1=in_m[10] A2=n_0_483 B1=in_m[9]
+ B2=n_0_404 C1=in_m[8] C2=n_0_351 VDD=VDD VSS=VSS
Xi_0_227 OAI211_X1 $PINS ZN=n_0_222 A=n_0_223 B=n_0_224 C1=n_0_493 C2=n_0_311
+ VDD=VDD VSS=VSS
Xi_0_226 AOI21_X1 $PINS ZN=n_0_221 A=n_0_222 B1=in_m[3] B2=n_0_264 VDD=VDD
+ VSS=VSS
Xi_0_225 AOI222_X1 $PINS ZN=n_0_220 A1=in_m[1] A2=n_0_240 B1=in_m[2] B2=n_0_245
+ C1=n_0_383 C2=n_0_320 VDD=VDD VSS=VSS
Xi_0_224 OAI211_X1 $PINS ZN=n_19 A=n_0_220 B=n_0_221 C1=n_0_492 C2=n_0_323
+ VDD=VDD VSS=VSS
Xi_0_223 AOI222_X1 $PINS ZN=n_0_219 A1=in_m[9] A2=n_0_483 B1=in_m[8] B2=n_0_404
+ C1=in_m[7] C2=n_0_351 VDD=VDD VSS=VSS
Xi_0_222 AOI22_X1 $PINS ZN=n_0_218 A1=in_m[6] A2=n_0_353 B1=in_m[5] B2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_221 AOI22_X1 $PINS ZN=n_0_217 A1=in_m[4] A2=n_0_310 B1=in_m[3] B2=n_0_322
+ VDD=VDD VSS=VSS
Xi_0_220 AOI222_X1 $PINS ZN=n_0_216 A1=in_m[2] A2=n_0_264 B1=in_m[0] B2=n_0_240
+ C1=in_m[1] C2=n_0_245 VDD=VDD VSS=VSS
Xi_0_219 NAND4_X1 $PINS ZN=n_18 A1=n_0_219 A2=n_0_216 A3=n_0_218 A4=n_0_217
+ VDD=VDD VSS=VSS
Xi_0_218 AOI222_X1 $PINS ZN=n_0_215 A1=in_m[7] A2=n_0_404 B1=in_m[5] B2=n_0_353
+ C1=in_m[8] C2=n_0_483 VDD=VDD VSS=VSS
Xi_0_217 OAI221_X1 $PINS ZN=n_0_214 A=n_0_215 B1=n_0_502 B2=n_0_321 C1=n_0_489
+ C2=n_0_263 VDD=VDD VSS=VSS
Xi_0_216 AOI221_X1 $PINS ZN=n_0_213 A=n_0_214 B1=in_m[4] B2=n_0_309 C1=in_m[6]
+ C2=n_0_351 VDD=VDD VSS=VSS
Xi_0_215 OAI221_X1 $PINS ZN=n_17 A=n_0_213 B1=n_0_491 B2=n_0_311 C1=n_0_490
+ C2=n_0_323 VDD=VDD VSS=VSS
Xi_0_214 AOI222_X1 $PINS ZN=n_0_212 A1=in_m[2] A2=n_0_310 B1=in_m[3] B2=n_0_309
+ C1=in_m[6] C2=n_0_404 VDD=VDD VSS=VSS
Xi_0_213 AOI222_X1 $PINS ZN=n_0_211 A1=in_m[0] A2=n_0_264 B1=in_m[7] B2=n_0_483
+ C1=in_m[5] C2=n_0_351 VDD=VDD VSS=VSS
Xi_0_212 AOI22_X1 $PINS ZN=n_0_210 A1=in_m[1] A2=n_0_322 B1=in_m[4] B2=n_0_353
+ VDD=VDD VSS=VSS
Xi_0_211 NAND3_X1 $PINS ZN=n_16 A1=n_0_211 A2=n_0_210 A3=n_0_212 VDD=VDD
+ VSS=VSS
Xi_0_210 AOI22_X1 $PINS ZN=n_0_209 A1=in_m[2] A2=n_0_309 B1=in_m[3] B2=n_0_353
+ VDD=VDD VSS=VSS
Xi_0_209 OAI222_X1 $PINS ZN=n_0_208 A1=n_0_493 A2=n_0_405 B1=n_0_494 B2=n_0_484
+ C1=n_0_492 C2=n_0_352 VDD=VDD VSS=VSS
Xi_0_208 AOI221_X1 $PINS ZN=n_0_207 A=n_0_208 B1=in_m[1] B2=n_0_310 C1=in_m[0]
+ C2=n_0_322 VDD=VDD VSS=VSS
Xi_0_207 NAND2_X1 $PINS ZN=n_15 A1=n_0_209 A2=n_0_207 VDD=VDD VSS=VSS
Xi_0_206 AOI22_X1 $PINS ZN=n_0_206 A1=in_m[0] A2=n_0_310 B1=in_m[1] B2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_205 AOI222_X1 $PINS ZN=n_0_205 A1=in_m[3] A2=n_0_351 B1=in_m[5] B2=n_0_483
+ C1=in_m[2] C2=n_0_353 VDD=VDD VSS=VSS
Xi_0_204 OAI211_X1 $PINS ZN=n_14 A=n_0_206 B=n_0_205 C1=n_0_492 C2=n_0_405
+ VDD=VDD VSS=VSS
Xi_0_203 AOI22_X1 $PINS ZN=n_0_204 A1=in_m[1] A2=n_0_353 B1=in_m[3] B2=n_0_404
+ VDD=VDD VSS=VSS
Xi_0_202 AOI22_X1 $PINS ZN=n_0_203 A1=in_m[0] A2=n_0_309 B1=in_m[2] B2=n_0_351
+ VDD=VDD VSS=VSS
Xi_0_201 OAI211_X1 $PINS ZN=n_13 A=n_0_204 B=n_0_203 C1=n_0_492 C2=n_0_484
+ VDD=VDD VSS=VSS
Xi_0_200 AOI22_X1 $PINS ZN=n_0_202 A1=in_m[0] A2=n_0_353 B1=in_m[1] B2=n_0_351
+ VDD=VDD VSS=VSS
Xi_0_199 OAI221_X1 $PINS ZN=n_12 A=n_0_202 B1=n_0_490 B2=n_0_405 C1=n_0_491
+ C2=n_0_484 VDD=VDD VSS=VSS
Xi_0_198 NOR3_X1 $PINS ZN=n_0_201 A1=in_m[20] A2=in_m[18] A3=in_m[16] VDD=VDD
+ VSS=VSS
Xi_0_197 NOR3_X1 $PINS ZN=n_0_200 A1=in_m[4] A2=n_0_394 A3=n_0_330 VDD=VDD
+ VSS=VSS
Xi_0_196 NAND3_X1 $PINS ZN=n_0_199 A1=n_0_466 A2=n_0_201 A3=n_0_200 VDD=VDD
+ VSS=VSS
Xi_0_195 NOR2_X1 $PINS ZN=n_0_198 A1=in_m[3] A2=n_0_199 VDD=VDD VSS=VSS
Xi_0_194 NAND4_X1 $PINS ZN=n_0_197 A1=n_0_501 A2=n_0_499 A3=n_0_509 A4=n_0_475
+ VDD=VDD VSS=VSS
Xi_0_193 NOR3_X1 $PINS ZN=n_0_196 A1=in_m[15] A2=in_m[7] A3=n_0_197 VDD=VDD
+ VSS=VSS
Xi_0_192 AOI21_X1 $PINS ZN=n_0_195 A=n_0_483 B1=n_0_198 B2=n_0_196 VDD=VDD
+ VSS=VSS
Xi_0_191 INV_X1 $PINS ZN=n_0_194 A=n_0_195 VDD=VDD VSS=VSS
Xi_0_190 AOI22_X1 $PINS ZN=n_0_193 A1=in_m[0] A2=n_0_351 B1=in_m[1] B2=n_0_404
+ VDD=VDD VSS=VSS
Xi_0_189 OAI21_X1 $PINS ZN=n_11 A=n_0_193 B1=n_0_490 B2=n_0_195 VDD=VDD VSS=VSS
Xi_0_188 NAND2_X1 $PINS ZN=n_0_192 A1=in_m[0] A2=n_0_404 VDD=VDD VSS=VSS
Xi_0_187 OAI21_X1 $PINS ZN=n_10 A=n_0_192 B1=n_0_489 B2=n_0_195 VDD=VDD VSS=VSS
Xi_0_186 AND2_X1 $PINS ZN=n_9 A1=in_m[0] A2=n_0_194 VDD=VDD VSS=VSS
Xi_0_185 NAND4_X1 $PINS ZN=n_0_191 A1=n_0_492 A2=n_0_491 A3=n_0_498 A4=n_0_201
+ VDD=VDD VSS=VSS
Xi_0_184 NAND3_X1 $PINS ZN=n_0_190 A1=n_0_509 A2=n_0_475 A3=n_0_393 VDD=VDD
+ VSS=VSS
Xi_0_183 NOR4_X1 $PINS ZN=n_0_189 A1=in_m[22] A2=in_m[15] A3=n_0_190 A4=n_0_191
+ VDD=VDD VSS=VSS
Xi_0_182 AOI21_X2 $PINS ZN=n_8 A=in_m[23] B1=n_0_340 B2=n_0_189 VDD=VDD VSS=VSS
Xi_0_181 NAND2_X1 $PINS ZN=n_0_22 A1=n_0_512 A2=n_0_511 VDD=VDD VSS=VSS
Xi_0_180 INV_X1 $PINS ZN=n_0_188 A=n_0_22 VDD=VDD VSS=VSS
Xi_0_179 AOI22_X1 $PINS ZN=n_0_187 A1=n_0_485 A2=n_0_322 B1=n_0_404 B2=n_0_188
+ VDD=VDD VSS=VSS
Xi_0_178 NAND2_X1 $PINS ZN=n_0_21 A1=n_0_511 A2=n_0_510 VDD=VDD VSS=VSS
Xi_0_177 INV_X1 $PINS ZN=n_0_186 A=n_0_21 VDD=VDD VSS=VSS
Xi_0_176 NAND2_X1 $PINS ZN=n_0_20 A1=n_0_510 A2=n_0_188 VDD=VDD VSS=VSS
Xi_0_175 INV_X1 $PINS ZN=n_0_185 A=n_0_20 VDD=VDD VSS=VSS
Xi_0_174 AOI21_X1 $PINS ZN=n_0_184 A=n_0_264 B1=n_0_487 B2=n_0_309 VDD=VDD
+ VSS=VSS
Xi_0_173 NAND2_X1 $PINS ZN=n_0_183 A1=n_0_512 A2=n_0_353 VDD=VDD VSS=VSS
Xi_0_172 OAI211_X1 $PINS ZN=n_0_182 A=n_0_183 B=n_0_184 C1=n_0_13 C2=n_0_311
+ VDD=VDD VSS=VSS
Xi_0_171 NOR2_X1 $PINS ZN=n_0_181 A1=in_e[2] A2=n_0_11 VDD=VDD VSS=VSS
Xi_0_170 INV_X1 $PINS ZN=n_0_19 A=n_0_181 VDD=VDD VSS=VSS
Xi_0_169 AOI221_X1 $PINS ZN=n_0_180 A=n_0_182 B1=n_0_351 B2=n_0_181 C1=n_0_194
+ C2=n_0_185 VDD=VDD VSS=VSS
Xi_0_168 AOI21_X1 $PINS ZN=n_0_179 A=n_0_182 B1=n_0_485 B2=n_0_322 VDD=VDD
+ VSS=VSS
Xi_0_167 AOI21_X1 $PINS ZN=n_0_178 A=in_e[3] B1=n_0_187 B2=n_0_180 VDD=VDD
+ VSS=VSS
Xi_0_166 INV_X1 $PINS ZN=n_0_177 A=n_0_178 VDD=VDD VSS=VSS
Xi_0_165 NAND2_X1 $PINS ZN=n_0_176 A1=n_0_451 A2=n_0_327 VDD=VDD VSS=VSS
Xi_0_164 NAND2_X1 $PINS ZN=n_0_175 A1=n_0_451 A2=n_0_435 VDD=VDD VSS=VSS
Xi_0_163 INV_X1 $PINS ZN=n_0_174 A=n_0_175 VDD=VDD VSS=VSS
Xi_0_162 OAI22_X1 $PINS ZN=n_0_173 A1=n_0_6 A2=n_0_334 B1=n_0_5 B2=n_0_423
+ VDD=VDD VSS=VSS
Xi_0_161 OAI22_X1 $PINS ZN=n_0_172 A1=n_0_0 A2=n_0_384 B1=n_0_1 B2=n_0_361
+ VDD=VDD VSS=VSS
Xi_0_160 INV_X1 $PINS ZN=n_0_171 A=n_0_172 VDD=VDD VSS=VSS
Xi_0_159 OAI221_X1 $PINS ZN=n_0_170 A=n_0_171 B1=n_0_3 B2=n_0_348 C1=n_0_4
+ C2=n_0_316 VDD=VDD VSS=VSS
Xi_0_158 AOI222_X1 $PINS ZN=n_0_169 A1=n_0_435 A2=n_0_170 B1=n_0_488 B2=n_0_245
+ C1=n_0_174 C2=n_0_173 VDD=VDD VSS=VSS
Xi_0_157 AND2_X1 $PINS ZN=n_0_168 A1=n_0_176 A2=n_0_169 VDD=VDD VSS=VSS
Xi_0_156 AOI21_X1 $PINS ZN=n_0_167 A=in_e[4] B1=n_0_177 B2=n_0_168 VDD=VDD
+ VSS=VSS
Xi_0_155 NOR2_X1 $PINS ZN=n_0_166 A1=in_m[16] A2=n_0_324 VDD=VDD VSS=VSS
Xi_0_154 NAND2_X1 $PINS ZN=n_0_165 A1=n_0_502 A2=n_0_166 VDD=VDD VSS=VSS
Xi_0_153 NOR2_X1 $PINS ZN=n_0_164 A1=in_m[12] A2=n_0_165 VDD=VDD VSS=VSS
Xi_0_152 AND2_X1 $PINS ZN=n_0_163 A1=n_0_329 A2=n_0_164 VDD=VDD VSS=VSS
Xi_0_151 AND2_X1 $PINS ZN=n_0_162 A1=n_0_196 A2=n_0_163 VDD=VDD VSS=VSS
Xi_0_150 NAND3_X1 $PINS ZN=n_0_161 A1=n_0_492 A2=n_0_393 A3=in_m[3] VDD=VDD
+ VSS=VSS
Xi_0_149 INV_X1 $PINS ZN=n_0_160 A=n_0_161 VDD=VDD VSS=VSS
Xi_0_148 OAI22_X1 $PINS ZN=n_0_159 A1=n_0_8 A2=n_0_434 B1=n_0_494 B2=n_0_7
+ VDD=VDD VSS=VSS
Xi_0_147 INV_X1 $PINS ZN=n_0_158 A=n_0_159 VDD=VDD VSS=VSS
Xi_0_146 NAND2_X1 $PINS ZN=n_0_157 A1=in_m[4] A2=n_0_393 VDD=VDD VSS=VSS
Xi_0_145 INV_X1 $PINS ZN=n_0_156 A=n_0_157 VDD=VDD VSS=VSS
Xi_0_144 OAI221_X1 $PINS ZN=n_0_155 A=n_0_158 B1=n_0_9 B2=n_0_157 C1=n_0_10
+ C2=n_0_161 VDD=VDD VSS=VSS
Xi_0_143 AOI21_X1 $PINS ZN=n_0_154 A=n_0_167 B1=n_0_162 B2=n_0_155 VDD=VDD
+ VSS=VSS
Xi_0_142 NOR2_X1 $PINS ZN=n_0_153 A1=in_e[5] A2=n_0_154 VDD=VDD VSS=VSS
Xi_0_141 NAND2_X1 $PINS ZN=n_0_152 A1=n_0_514 A2=n_0_153 VDD=VDD VSS=VSS
Xi_0_140 XNOR2_X1 $PINS ZN=n_7 A=in_e[7] B=n_0_152 VDD=VDD VSS=VSS
Xi_0_139 OAI21_X1 $PINS ZN=n_6 A=n_0_152 B1=n_0_514 B2=n_0_153 VDD=VDD VSS=VSS
Xi_0_138 AOI21_X1 $PINS ZN=n_0_151 A=n_0_153 B1=in_e[5] B2=n_0_154 VDD=VDD
+ VSS=VSS
Xi_0_137 INV_X1 $PINS ZN=n_5 A=n_0_151 VDD=VDD VSS=VSS
Xi_0_136 OAI22_X1 $PINS ZN=n_0_150 A1=n_0_404 A2=n_0_322 B1=in_e[3] B2=n_0_187
+ VDD=VDD VSS=VSS
Xi_0_135 AOI21_X1 $PINS ZN=n_0_149 A=n_0_513 B1=n_0_311 B2=n_0_263 VDD=VDD
+ VSS=VSS
Xi_0_134 NAND2_X1 $PINS ZN=n_0_148 A1=n_0_1 A2=n_0_360 VDD=VDD VSS=VSS
Xi_0_133 AOI22_X1 $PINS ZN=n_0_147 A1=n_0_3 A2=n_0_347 B1=n_0_0 B2=n_0_383
+ VDD=VDD VSS=VSS
Xi_0_132 AOI222_X1 $PINS ZN=n_0_146 A1=n_0_5 A2=n_0_296 B1=n_0_4 B2=n_0_315
+ C1=in_m[14] C2=n_0_2 VDD=VDD VSS=VSS
Xi_0_131 NAND3_X1 $PINS ZN=n_0_145 A1=n_0_147 A2=n_0_146 A3=n_0_148 VDD=VDD
+ VSS=VSS
Xi_0_130 AOI221_X1 $PINS ZN=n_0_144 A=n_0_149 B1=n_0_435 B2=n_0_145 C1=n_0_13
+ C2=n_0_310 VDD=VDD VSS=VSS
Xi_0_129 AOI21_X1 $PINS ZN=n_0_143 A=n_0_308 B1=n_0_513 B2=n_0_487 VDD=VDD
+ VSS=VSS
Xi_0_128 AOI21_X1 $PINS ZN=n_0_142 A=n_0_143 B1=n_0_479 B2=n_0_373 VDD=VDD
+ VSS=VSS
Xi_0_127 NAND2_X1 $PINS ZN=n_0_18 A1=n_0_513 A2=n_0_512 VDD=VDD VSS=VSS
Xi_0_126 INV_X1 $PINS ZN=n_0_141 A=n_0_18 VDD=VDD VSS=VSS
Xi_0_125 AOI22_X1 $PINS ZN=n_0_140 A1=n_0_12 A2=n_0_309 B1=n_0_351 B2=n_0_19
+ VDD=VDD VSS=VSS
Xi_0_124 AOI21_X1 $PINS ZN=n_0_139 A=n_0_142 B1=n_0_141 B2=n_0_140 VDD=VDD
+ VSS=VSS
Xi_0_123 NAND2_X1 $PINS ZN=n_0_17 A1=n_0_511 A2=n_0_141 VDD=VDD VSS=VSS
Xi_0_122 NAND2_X1 $PINS ZN=n_0_16 A1=n_0_186 A2=n_0_141 VDD=VDD VSS=VSS
Xi_0_121 NAND3_X1 $PINS ZN=n_0_138 A1=n_0_333 A2=n_0_174 A3=n_0_6 VDD=VDD
+ VSS=VSS
Xi_0_120 AOI21_X1 $PINS ZN=n_0_137 A=n_0_139 B1=n_0_194 B2=n_0_16 VDD=VDD
+ VSS=VSS
Xi_0_119 NAND4_X1 $PINS ZN=n_0_136 A1=n_0_138 A2=n_0_137 A3=n_0_144 A4=n_0_150
+ VDD=VDD VSS=VSS
Xi_0_118 AOI22_X1 $PINS ZN=n_0_135 A1=in_m[6] A2=n_0_30 B1=n_0_31 B2=n_0_433
+ VDD=VDD VSS=VSS
Xi_0_117 AOI22_X1 $PINS ZN=n_0_134 A1=n_0_33 A2=n_0_160 B1=n_0_32 B2=n_0_156
+ VDD=VDD VSS=VSS
Xi_0_116 NAND2_X1 $PINS ZN=n_0_133 A1=n_0_135 A2=n_0_134 VDD=VDD VSS=VSS
Xi_0_115 AOI221_X1 $PINS ZN=n_0_132 A=n_0_167 B1=n_0_162 B2=n_0_133 C1=in_e[4]
+ C2=n_0_136 VDD=VDD VSS=VSS
Xi_0_114 INV_X1 $PINS ZN=n_4 A=n_0_132 VDD=VDD VSS=VSS
Xi_0_113 NAND2_X1 $PINS ZN=n_0_131 A1=n_0_14 A2=n_0_322 VDD=VDD VSS=VSS
Xi_0_112 AOI22_X1 $PINS ZN=n_0_130 A1=n_0_13 A2=n_0_310 B1=in_e[2] B2=n_0_353
+ VDD=VDD VSS=VSS
Xi_0_111 NAND4_X1 $PINS ZN=n_0_129 A1=n_0_140 A2=n_0_130 A3=n_0_131 A4=n_0_176
+ VDD=VDD VSS=VSS
Xi_0_110 AOI22_X1 $PINS ZN=n_0_128 A1=n_0_186 A2=n_0_141 B1=in_e[3] B2=n_0_20
+ VDD=VDD VSS=VSS
Xi_0_109 AOI221_X1 $PINS ZN=n_0_127 A=n_0_197 B1=in_e[3] B2=in_m[15] C1=n_0_513
+ C2=in_m[7] VDD=VDD VSS=VSS
Xi_0_108 AOI21_X1 $PINS ZN=n_0_126 A=n_0_483 B1=n_0_198 B2=n_0_127 VDD=VDD
+ VSS=VSS
Xi_0_107 OAI21_X1 $PINS ZN=n_0_125 A=n_0_17 B1=n_0_513 B2=n_0_188 VDD=VDD
+ VSS=VSS
Xi_0_106 AND3_X1 $PINS ZN=n_0_124 A1=n_0_513 A2=n_0_11 A3=n_0_156 VDD=VDD
+ VSS=VSS
Xi_0_105 OAI211_X1 $PINS ZN=n_0_123 A=in_e[3] B=n_0_19 C1=in_e[2] C2=in_m[4]
+ VDD=VDD VSS=VSS
Xi_0_104 AOI22_X1 $PINS ZN=n_0_122 A1=n_0_492 A2=n_0_491 B1=n_0_18 B2=n_0_123
+ VDD=VDD VSS=VSS
Xi_0_103 AOI222_X1 $PINS ZN=n_0_121 A1=in_m[14] A2=n_0_23 B1=n_0_24 B2=n_0_360
+ C1=n_0_25 C2=n_0_383 VDD=VDD VSS=VSS
Xi_0_102 AOI22_X1 $PINS ZN=n_0_120 A1=n_0_26 A2=n_0_347 B1=n_0_27 B2=n_0_315
+ VDD=VDD VSS=VSS
Xi_0_101 AOI21_X1 $PINS ZN=n_0_119 A=n_0_436 B1=n_0_121 B2=n_0_120 VDD=VDD
+ VSS=VSS
Xi_0_100 INV_X1 $PINS ZN=n_0_118 A=n_0_119 VDD=VDD VSS=VSS
Xi_0_99 NAND2_X1 $PINS ZN=n_0_117 A1=n_0_503 A2=n_0_28 VDD=VDD VSS=VSS
Xi_0_98 NAND2_X1 $PINS ZN=n_0_116 A1=n_0_404 A2=n_0_125 VDD=VDD VSS=VSS
Xi_0_97 NAND2_X1 $PINS ZN=n_0_15 A1=n_0_513 A2=n_0_181 VDD=VDD VSS=VSS
Xi_0_96 OAI33_X1 $PINS ZN=n_0_115 A1=n_0_334 A2=n_0_175 A3=n_0_486 B1=n_0_416
+ B2=n_0_297 B3=n_0_117 VDD=VDD VSS=VSS
Xi_0_95 OAI211_X1 $PINS ZN=n_0_114 A=n_0_116 B=n_0_118 C1=n_0_352 C2=n_0_15
+ VDD=VDD VSS=VSS
Xi_0_94 OAI221_X1 $PINS ZN=n_0_113 A=n_0_127 B1=n_0_434 B2=n_0_125 C1=n_0_394
+ C2=n_0_122 VDD=VDD VSS=VSS
Xi_0_93 AOI211_X1 $PINS ZN=n_0_112 A=n_0_124 B=n_0_113 C1=in_m[6] C2=n_0_128
+ VDD=VDD VSS=VSS
Xi_0_92 AOI211_X1 $PINS ZN=n_0_111 A=n_0_115 B=n_0_114 C1=n_0_163 C2=n_0_112
+ VDD=VDD VSS=VSS
Xi_0_91 INV_X1 $PINS ZN=n_0_110 A=n_0_111 VDD=VDD VSS=VSS
Xi_0_90 AOI21_X1 $PINS ZN=n_0_109 A=n_0_110 B1=in_e[3] B2=n_0_129 VDD=VDD
+ VSS=VSS
Xi_0_89 OAI221_X1 $PINS ZN=n_3 A=n_0_109 B1=n_0_128 B2=n_0_126 C1=in_e[3]
+ C2=n_0_179 VDD=VDD VSS=VSS
Xi_0_88 OAI21_X1 $PINS ZN=n_0_108 A=n_0_20 B1=n_0_512 B2=n_0_186 VDD=VDD
+ VSS=VSS
Xi_0_87 NOR2_X1 $PINS ZN=n_0_107 A1=n_0_512 A2=n_0_197 VDD=VDD VSS=VSS
Xi_0_86 INV_X1 $PINS ZN=n_0_106 A=n_0_107 VDD=VDD VSS=VSS
Xi_0_85 NOR3_X1 $PINS ZN=n_0_105 A1=in_m[17] A2=in_m[15] A3=in_m[13] VDD=VDD
+ VSS=VSS
Xi_0_84 NAND3_X1 $PINS ZN=n_0_104 A1=n_0_512 A2=n_0_509 A3=n_0_105 VDD=VDD
+ VSS=VSS
Xi_0_83 INV_X1 $PINS ZN=n_0_103 A=n_0_104 VDD=VDD VSS=VSS
Xi_0_82 NAND2_X1 $PINS ZN=n_0_102 A1=n_0_495 A2=n_0_103 VDD=VDD VSS=VSS
Xi_0_81 AOI21_X1 $PINS ZN=n_0_101 A=n_0_483 B1=n_0_198 B2=n_0_107 VDD=VDD
+ VSS=VSS
Xi_0_80 OAI21_X1 $PINS ZN=n_0_100 A=n_0_101 B1=n_0_199 B2=n_0_102 VDD=VDD
+ VSS=VSS
Xi_0_79 AOI211_X1 $PINS ZN=n_0_99 A=in_e[1] B=n_0_454 C1=in_e[0] C2=in_m[14]
+ VDD=VDD VSS=VSS
Xi_0_78 INV_X1 $PINS ZN=n_0_98 A=n_0_99 VDD=VDD VSS=VSS
Xi_0_77 AOI21_X1 $PINS ZN=n_0_97 A=n_0_181 B1=in_e[2] B2=n_0_11 VDD=VDD VSS=VSS
Xi_0_76 INV_X1 $PINS ZN=n_0_96 A=n_0_97 VDD=VDD VSS=VSS
Xi_0_75 AOI21_X1 $PINS ZN=n_0_95 A=n_0_455 B1=in_m[12] B2=n_0_96 VDD=VDD
+ VSS=VSS
Xi_0_74 OAI21_X1 $PINS ZN=n_0_94 A=n_0_503 B1=n_0_99 B2=n_0_95 VDD=VDD VSS=VSS
Xi_0_73 AOI22_X1 $PINS ZN=n_0_93 A1=in_e[1] A2=n_0_404 B1=n_0_415 B2=n_0_94
+ VDD=VDD VSS=VSS
Xi_0_72 OAI221_X1 $PINS ZN=n_0_92 A=n_0_512 B1=n_0_507 B2=n_0_478 C1=n_0_290
+ C2=n_0_98 VDD=VDD VSS=VSS
Xi_0_71 NAND2_X1 $PINS ZN=n_0_91 A1=in_e[2] A2=n_0_93 VDD=VDD VSS=VSS
Xi_0_70 AOI22_X1 $PINS ZN=n_0_90 A1=n_0_108 A2=n_0_100 B1=n_0_92 B2=n_0_91
+ VDD=VDD VSS=VSS
Xi_0_69 AOI22_X1 $PINS ZN=n_0_89 A1=n_0_404 A2=n_0_188 B1=n_0_35 B2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_68 OAI21_X1 $PINS ZN=n_0_88 A=n_0_21 B1=in_e[1] B2=in_m[6] VDD=VDD VSS=VSS
Xi_0_67 NAND2_X1 $PINS ZN=n_0_87 A1=in_e[2] A2=n_0_88 VDD=VDD VSS=VSS
Xi_0_66 OAI211_X1 $PINS ZN=n_0_86 A=n_0_87 B=n_0_394 C1=in_e[2] C2=n_0_88
+ VDD=VDD VSS=VSS
Xi_0_65 AOI221_X1 $PINS ZN=n_0_85 A=in_m[7] B1=n_0_156 B2=n_0_96 C1=n_0_160
+ C2=n_0_103 VDD=VDD VSS=VSS
Xi_0_64 AOI221_X1 $PINS ZN=n_0_84 A=n_0_330 B1=in_m[7] B2=n_0_106 C1=n_0_86
+ C2=n_0_85 VDD=VDD VSS=VSS
Xi_0_63 AOI22_X1 $PINS ZN=n_0_83 A1=in_m[10] A2=n_0_35 B1=n_0_36 B2=n_0_422
+ VDD=VDD VSS=VSS
Xi_0_62 AOI21_X1 $PINS ZN=n_0_82 A=n_0_84 B1=n_0_37 B2=n_0_333 VDD=VDD VSS=VSS
Xi_0_61 AOI222_X1 $PINS ZN=n_0_81 A1=n_0_37 A2=n_0_322 B1=n_0_36 B2=n_0_310
+ C1=n_0_351 C2=n_0_96 VDD=VDD VSS=VSS
Xi_0_60 AOI22_X1 $PINS ZN=n_0_80 A1=n_0_83 A2=n_0_82 B1=n_0_106 B2=n_0_104
+ VDD=VDD VSS=VSS
Xi_0_59 AOI211_X1 $PINS ZN=n_0_79 A=n_0_165 B=n_0_453 C1=in_m[12] C2=n_0_97
+ VDD=VDD VSS=VSS
Xi_0_58 AOI22_X1 $PINS ZN=n_0_78 A1=n_0_164 A2=n_0_80 B1=n_0_103 B2=n_0_79
+ VDD=VDD VSS=VSS
Xi_0_57 NAND4_X1 $PINS ZN=n_2 A1=n_0_89 A2=n_0_81 A3=n_0_78 A4=n_0_90 VDD=VDD
+ VSS=VSS
Xi_0_56 OAI22_X1 $PINS ZN=n_0_77 A1=n_0_507 A2=n_0_478 B1=n_0_510 B2=n_0_308
+ VDD=VDD VSS=VSS
Xi_0_55 AOI21_X1 $PINS ZN=n_0_76 A=n_0_186 B1=in_e[1] B2=in_e[0] VDD=VDD
+ VSS=VSS
Xi_0_54 INV_X1 $PINS ZN=n_0_75 A=n_0_76 VDD=VDD VSS=VSS
Xi_0_53 NAND3_X1 $PINS ZN=n_0_74 A1=n_0_511 A2=n_0_507 A3=n_0_503 VDD=VDD
+ VSS=VSS
Xi_0_52 INV_X1 $PINS ZN=n_0_73 A=n_0_74 VDD=VDD VSS=VSS
Xi_0_51 NAND3_X1 $PINS ZN=n_0_72 A1=n_0_496 A2=n_0_458 A3=n_0_73 VDD=VDD
+ VSS=VSS
Xi_0_50 NAND3_X1 $PINS ZN=n_0_71 A1=in_e[1] A2=n_0_509 A3=n_0_505 VDD=VDD
+ VSS=VSS
Xi_0_49 INV_X1 $PINS ZN=n_0_70 A=n_0_71 VDD=VDD VSS=VSS
Xi_0_48 OAI33_X1 $PINS ZN=n_0_69 A1=n_0_363 A2=n_0_72 A3=n_0_191 B1=in_m[13]
+ B2=n_0_71 B3=n_0_199 VDD=VDD VSS=VSS
Xi_0_47 OAI21_X1 $PINS ZN=n_0_68 A=n_0_75 B1=n_0_483 B2=n_0_69 VDD=VDD VSS=VSS
Xi_0_46 AOI21_X1 $PINS ZN=n_0_67 A=n_0_73 B1=n_0_501 B2=n_0_70 VDD=VDD VSS=VSS
Xi_0_45 AOI21_X1 $PINS ZN=n_0_66 A=n_0_70 B1=n_0_511 B2=n_0_507 VDD=VDD VSS=VSS
Xi_0_44 OAI33_X1 $PINS ZN=n_0_65 A1=n_0_500 A2=n_0_165 A3=n_0_67 B1=n_0_504
+ B2=n_0_324 B3=n_0_66 VDD=VDD VSS=VSS
Xi_0_43 OR2_X1 $PINS ZN=n_0_64 A1=n_0_351 A2=n_0_65 VDD=VDD VSS=VSS
Xi_0_42 AOI21_X1 $PINS ZN=n_0_63 A=in_m[18] B1=in_m[14] B2=n_0_469 VDD=VDD
+ VSS=VSS
Xi_0_41 OAI22_X1 $PINS ZN=n_0_62 A1=in_m[18] A2=n_0_505 B1=n_0_76 B2=n_0_63
+ VDD=VDD VSS=VSS
Xi_0_40 NAND3_X1 $PINS ZN=n_0_61 A1=n_0_508 A2=n_0_507 A3=n_0_62 VDD=VDD
+ VSS=VSS
Xi_0_39 AOI211_X1 $PINS ZN=n_0_60 A=in_e[1] B=n_0_483 C1=n_0_509 C2=n_0_61
+ VDD=VDD VSS=VSS
Xi_0_38 NAND2_X1 $PINS ZN=n_0_59 A1=in_m[6] A2=n_0_75 VDD=VDD VSS=VSS
Xi_0_37 NAND3_X1 $PINS ZN=n_0_58 A1=n_0_495 A2=n_0_161 A3=n_0_59 VDD=VDD
+ VSS=VSS
Xi_0_36 AOI21_X1 $PINS ZN=n_0_57 A=n_0_448 B1=n_0_496 B2=n_0_157 VDD=VDD
+ VSS=VSS
Xi_0_35 OAI21_X1 $PINS ZN=n_0_56 A=n_0_499 B1=n_0_498 B2=n_0_76 VDD=VDD VSS=VSS
Xi_0_34 AOI221_X1 $PINS ZN=n_0_55 A=n_0_56 B1=n_0_34 B2=n_0_57 C1=n_0_329
+ C2=n_0_58 VDD=VDD VSS=VSS
Xi_0_33 OAI221_X1 $PINS ZN=n_0_54 A=n_0_503 B1=n_0_76 B2=n_0_63 C1=n_0_425
+ C2=n_0_55 VDD=VDD VSS=VSS
Xi_0_32 NAND3_X1 $PINS ZN=n_0_53 A1=n_0_166 A2=n_0_70 A3=n_0_54 VDD=VDD VSS=VSS
Xi_0_31 AOI21_X1 $PINS ZN=n_0_52 A=in_m[7] B1=n_0_434 B2=n_0_59 VDD=VDD VSS=VSS
Xi_0_30 NAND2_X1 $PINS ZN=n_0_51 A1=n_0_496 A2=n_0_52 VDD=VDD VSS=VSS
Xi_0_29 NAND3_X1 $PINS ZN=n_0_50 A1=n_0_495 A2=in_m[4] A3=n_0_494 VDD=VDD
+ VSS=VSS
Xi_0_28 NAND2_X1 $PINS ZN=n_0_49 A1=n_0_496 A2=n_0_50 VDD=VDD VSS=VSS
Xi_0_27 AOI21_X1 $PINS ZN=n_0_48 A=n_0_448 B1=n_0_34 B2=n_0_49 VDD=VDD VSS=VSS
Xi_0_26 AOI221_X1 $PINS ZN=n_0_47 A=n_0_60 B1=in_e[1] B2=n_0_77 C1=n_0_34
+ C2=n_0_64 VDD=VDD VSS=VSS
Xi_0_25 AOI22_X1 $PINS ZN=n_0_46 A1=n_0_51 A2=n_0_48 B1=in_m[10] B2=n_0_76
+ VDD=VDD VSS=VSS
Xi_0_24 NAND2_X1 $PINS ZN=n_0_45 A1=n_0_453 A2=n_0_46 VDD=VDD VSS=VSS
Xi_0_23 AOI211_X1 $PINS ZN=n_0_44 A=n_0_165 B=n_0_74 C1=n_0_501 C2=n_0_45
+ VDD=VDD VSS=VSS
Xi_0_22 INV_X1 $PINS ZN=n_0_43 A=n_0_44 VDD=VDD VSS=VSS
Xi_0_21 NAND4_X1 $PINS ZN=n_1 A1=n_0_68 A2=n_0_53 A3=n_0_43 A4=n_0_47 VDD=VDD
+ VSS=VSS
Xi_0_20 NOR3_X1 $PINS ZN=n_0_42 A1=in_m[9] A2=in_m[7] A3=n_0_433 VDD=VDD
+ VSS=VSS
Xi_0_19 AOI21_X1 $PINS ZN=n_0_41 A=in_m[10] B1=n_0_161 B2=n_0_42 VDD=VDD
+ VSS=VSS
Xi_0_18 AOI21_X1 $PINS ZN=n_0_40 A=in_m[11] B1=n_0_334 B2=n_0_41 VDD=VDD
+ VSS=VSS
Xi_0_17 OAI211_X1 $PINS ZN=n_0_39 A=n_0_503 B=n_0_361 C1=n_0_467 C2=n_0_40
+ VDD=VDD VSS=VSS
Xi_0_16 AOI221_X1 $PINS ZN=n_0_38 A=n_0_353 B1=n_0_403 B2=n_0_402 C1=n_0_166
+ C2=n_0_39 VDD=VDD VSS=VSS
Xi_0_15 XOR2_X1 $PINS Z=n_0 A=in_e[0] B=n_0_38 VDD=VDD VSS=VSS
Xi_0_14 HA_X1 $PINS CO=n_0_14 S=n_0_37 A=in_e[2] B=n_0_11 VDD=VDD VSS=VSS
Xi_0_13 HA_X1 $PINS CO=n_0_13 S=n_0_36 A=in_e[2] B=in_e[1] VDD=VDD VSS=VSS
Xi_0_12 HA_X1 $PINS CO=n_0_12 S=n_0_35 A=in_e[2] B=n_0_21 VDD=VDD VSS=VSS
Xi_0_11 HA_X1 $PINS CO=n_0_11 S=n_0_34 A=in_e[1] B=in_e[0] VDD=VDD VSS=VSS
Xi_0_10 HA_X1 $PINS CO=n_0_10 S=n_0_33 A=in_e[4] B=n_0_18 VDD=VDD VSS=VSS
Xi_0_9 HA_X1 $PINS CO=n_0_9 S=n_0_32 A=in_e[4] B=n_0_15 VDD=VDD VSS=VSS
Xi_0_8 HA_X1 $PINS CO=n_0_8 S=n_0_31 A=in_e[4] B=n_0_17 VDD=VDD VSS=VSS
Xi_0_7 HA_X1 $PINS CO=n_0_7 S=n_0_30 A=in_e[4] B=n_0_16 VDD=VDD VSS=VSS
Xi_0_6 HA_X1 $PINS CO=n_0_6 S=n_0_29 A=in_e[3] B=n_0_14 VDD=VDD VSS=VSS
Xi_0_5 HA_X1 $PINS CO=n_0_5 S=n_0_28 A=in_e[3] B=n_0_13 VDD=VDD VSS=VSS
Xi_0_4 HA_X1 $PINS CO=n_0_4 S=n_0_27 A=in_e[3] B=n_0_12 VDD=VDD VSS=VSS
Xi_0_3 HA_X1 $PINS CO=n_0_3 S=n_0_26 A=in_e[3] B=in_e[2] VDD=VDD VSS=VSS
Xi_0_2 HA_X1 $PINS CO=n_0_0 S=n_0_25 A=in_e[3] B=n_0_19 VDD=VDD VSS=VSS
Xi_0_1 HA_X1 $PINS CO=n_0_1 S=n_0_24 A=in_e[3] B=n_0_22 VDD=VDD VSS=VSS
Xi_0_0 HA_X1 $PINS CO=n_0_2 S=n_0_23 A=in_e[3] B=n_0_20 VDD=VDD VSS=VSS
Xout_e_reg[0] DLH_X1 $PINS Q=out_e[0] D=n_0 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[1] DLH_X1 $PINS Q=out_e[1] D=n_1 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[2] DLH_X1 $PINS Q=out_e[2] D=n_2 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[3] DLH_X1 $PINS Q=out_e[3] D=n_3 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[4] DLH_X1 $PINS Q=out_e[4] D=n_4 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[5] DLH_X1 $PINS Q=out_e[5] D=n_5 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[6] DLH_X1 $PINS Q=out_e[6] D=n_6 G=n_8 VDD=VDD VSS=VSS
Xout_e_reg[7] DLH_X1 $PINS Q=out_e[7] D=n_7 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[1] DLH_X1 $PINS Q=out_m[1] D=n_9 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[2] DLH_X1 $PINS Q=out_m[2] D=n_10 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[3] DLH_X1 $PINS Q=out_m[3] D=n_11 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[4] DLH_X1 $PINS Q=out_m[4] D=n_12 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[5] DLH_X1 $PINS Q=out_m[5] D=n_13 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[6] DLH_X1 $PINS Q=out_m[6] D=n_14 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[7] DLH_X1 $PINS Q=out_m[7] D=n_15 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[8] DLH_X1 $PINS Q=out_m[8] D=n_16 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[9] DLH_X1 $PINS Q=out_m[9] D=n_17 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[10] DLH_X1 $PINS Q=out_m[10] D=n_18 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[11] DLH_X1 $PINS Q=out_m[11] D=n_19 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[12] DLH_X1 $PINS Q=out_m[12] D=n_20 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[13] DLH_X1 $PINS Q=out_m[13] D=n_21 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[14] DLH_X1 $PINS Q=out_m[14] D=n_22 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[15] DLH_X1 $PINS Q=out_m[15] D=n_23 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[16] DLH_X1 $PINS Q=out_m[16] D=n_24 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[17] DLH_X1 $PINS Q=out_m[17] D=n_25 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[18] DLH_X1 $PINS Q=out_m[18] D=n_26 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[19] DLH_X1 $PINS Q=out_m[19] D=n_27 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[20] DLH_X1 $PINS Q=out_m[20] D=n_28 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[21] DLH_X1 $PINS Q=out_m[21] D=n_29 G=n_8 VDD=VDD VSS=VSS
Xout_m_reg[22] DLH_X1 $PINS Q=out_m[22] D=n_30 G=n_8 VDD=VDD VSS=VSS
.ENDS

.SUBCKT adder VDD VSS a[31] a[30] a[29] a[28] a[27] a[26] a[25] a[24] a[23]
+ a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12] a[11] a[10]
+ a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b[31] b[30] b[29] b[28]
+ b[27] b[26] b[25] b[24] b[23] b[22] b[21] b[20] b[19] b[18] b[17] b[16] b[15]
+ b[14] b[13] b[12] b[11] b[10] b[9] b[8] b[7] b[6] b[5] b[4] b[3] b[2] b[1]
+ b[0] out[31] out[30] out[29] out[28] out[27] out[26] out[25] out[24] out[23]
+ out[22] out[21] out[20] out[19] out[18] out[17] out[16] out[15] out[14]
+ out[13] out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5] out[4]
+ out[3] out[2] out[1] out[0] of
Xi_0_619 INV_X1 $PINS ZN=n_0_536 A=b[30] VDD=VDD VSS=VSS
Xi_0_618 INV_X1 $PINS ZN=n_0_535 A=b[29] VDD=VDD VSS=VSS
Xi_0_617 INV_X1 $PINS ZN=n_0_534 A=b[28] VDD=VDD VSS=VSS
Xi_0_616 INV_X1 $PINS ZN=n_0_533 A=b[27] VDD=VDD VSS=VSS
Xi_0_615 INV_X1 $PINS ZN=n_0_532 A=b[26] VDD=VDD VSS=VSS
Xi_0_614 INV_X1 $PINS ZN=n_0_531 A=b[25] VDD=VDD VSS=VSS
Xi_0_613 INV_X1 $PINS ZN=n_0_530 A=b[24] VDD=VDD VSS=VSS
Xi_0_612 INV_X1 $PINS ZN=n_0_529 A=b[23] VDD=VDD VSS=VSS
Xi_0_611 INV_X1 $PINS ZN=n_0_528 A=b[22] VDD=VDD VSS=VSS
Xi_0_610 INV_X1 $PINS ZN=n_0_527 A=b[21] VDD=VDD VSS=VSS
Xi_0_609 INV_X1 $PINS ZN=n_0_526 A=b[20] VDD=VDD VSS=VSS
Xi_0_608 INV_X1 $PINS ZN=n_0_525 A=b[19] VDD=VDD VSS=VSS
Xi_0_607 INV_X1 $PINS ZN=n_0_524 A=b[18] VDD=VDD VSS=VSS
Xi_0_606 INV_X1 $PINS ZN=n_0_523 A=b[17] VDD=VDD VSS=VSS
Xi_0_605 INV_X1 $PINS ZN=n_0_522 A=b[15] VDD=VDD VSS=VSS
Xi_0_604 INV_X1 $PINS ZN=n_0_521 A=b[14] VDD=VDD VSS=VSS
Xi_0_603 INV_X1 $PINS ZN=n_0_520 A=b[13] VDD=VDD VSS=VSS
Xi_0_602 INV_X1 $PINS ZN=n_0_519 A=b[12] VDD=VDD VSS=VSS
Xi_0_601 INV_X1 $PINS ZN=n_0_518 A=b[11] VDD=VDD VSS=VSS
Xi_0_600 INV_X1 $PINS ZN=n_0_517 A=b[10] VDD=VDD VSS=VSS
Xi_0_599 INV_X1 $PINS ZN=n_0_516 A=b[9] VDD=VDD VSS=VSS
Xi_0_598 INV_X1 $PINS ZN=n_0_515 A=b[8] VDD=VDD VSS=VSS
Xi_0_597 INV_X1 $PINS ZN=n_0_514 A=b[7] VDD=VDD VSS=VSS
Xi_0_596 INV_X1 $PINS ZN=n_0_513 A=b[6] VDD=VDD VSS=VSS
Xi_0_595 INV_X1 $PINS ZN=n_0_512 A=b[5] VDD=VDD VSS=VSS
Xi_0_594 INV_X1 $PINS ZN=n_0_511 A=b[4] VDD=VDD VSS=VSS
Xi_0_593 INV_X1 $PINS ZN=n_0_510 A=b[3] VDD=VDD VSS=VSS
Xi_0_592 INV_X1 $PINS ZN=n_0_509 A=b[2] VDD=VDD VSS=VSS
Xi_0_591 INV_X1 $PINS ZN=n_0_508 A=b[1] VDD=VDD VSS=VSS
Xi_0_590 INV_X1 $PINS ZN=n_0_507 A=b[0] VDD=VDD VSS=VSS
Xi_0_589 INV_X1 $PINS ZN=n_0_506 A=a[30] VDD=VDD VSS=VSS
Xi_0_588 INV_X1 $PINS ZN=n_0_505 A=a[29] VDD=VDD VSS=VSS
Xi_0_587 INV_X1 $PINS ZN=n_0_504 A=a[28] VDD=VDD VSS=VSS
Xi_0_586 INV_X1 $PINS ZN=n_0_503 A=a[27] VDD=VDD VSS=VSS
Xi_0_585 INV_X1 $PINS ZN=n_0_502 A=a[26] VDD=VDD VSS=VSS
Xi_0_584 INV_X1 $PINS ZN=n_0_501 A=a[25] VDD=VDD VSS=VSS
Xi_0_583 INV_X1 $PINS ZN=n_0_500 A=a[24] VDD=VDD VSS=VSS
Xi_0_582 INV_X1 $PINS ZN=n_0_499 A=a[23] VDD=VDD VSS=VSS
Xi_0_581 INV_X1 $PINS ZN=n_0_498 A=a[22] VDD=VDD VSS=VSS
Xi_0_580 INV_X1 $PINS ZN=n_0_497 A=a[21] VDD=VDD VSS=VSS
Xi_0_579 INV_X1 $PINS ZN=n_0_496 A=a[20] VDD=VDD VSS=VSS
Xi_0_578 INV_X1 $PINS ZN=n_0_495 A=a[19] VDD=VDD VSS=VSS
Xi_0_577 INV_X1 $PINS ZN=n_0_494 A=a[18] VDD=VDD VSS=VSS
Xi_0_576 INV_X1 $PINS ZN=n_0_493 A=a[17] VDD=VDD VSS=VSS
Xi_0_575 INV_X1 $PINS ZN=n_0_492 A=a[16] VDD=VDD VSS=VSS
Xi_0_574 INV_X1 $PINS ZN=n_0_491 A=a[15] VDD=VDD VSS=VSS
Xi_0_573 INV_X1 $PINS ZN=n_0_490 A=a[14] VDD=VDD VSS=VSS
Xi_0_572 INV_X1 $PINS ZN=n_0_489 A=a[13] VDD=VDD VSS=VSS
Xi_0_571 INV_X1 $PINS ZN=n_0_488 A=a[12] VDD=VDD VSS=VSS
Xi_0_570 INV_X1 $PINS ZN=n_0_487 A=a[11] VDD=VDD VSS=VSS
Xi_0_569 INV_X1 $PINS ZN=n_0_486 A=a[10] VDD=VDD VSS=VSS
Xi_0_568 INV_X1 $PINS ZN=n_0_485 A=a[9] VDD=VDD VSS=VSS
Xi_0_567 INV_X1 $PINS ZN=n_0_484 A=a[8] VDD=VDD VSS=VSS
Xi_0_566 INV_X1 $PINS ZN=n_0_483 A=a[7] VDD=VDD VSS=VSS
Xi_0_565 INV_X1 $PINS ZN=n_0_482 A=a[6] VDD=VDD VSS=VSS
Xi_0_564 INV_X1 $PINS ZN=n_0_481 A=a[4] VDD=VDD VSS=VSS
Xi_0_563 INV_X1 $PINS ZN=n_0_480 A=a[2] VDD=VDD VSS=VSS
Xi_0_562 INV_X1 $PINS ZN=n_0_479 A=CLA_SUM[22] VDD=VDD VSS=VSS
Xi_0_561 INV_X1 $PINS ZN=n_0_478 A=n_0_5 VDD=VDD VSS=VSS
Xi_0_560 NAND2_X1 $PINS ZN=n_56 A1=n_0_536 A2=n_0_506 VDD=VDD VSS=VSS
Xi_0_559 INV_X1 $PINS ZN=n_0_477 A=n_56 VDD=VDD VSS=VSS
Xi_0_558 NAND2_X1 $PINS ZN=n_0_476 A1=n_0_535 A2=a[29] VDD=VDD VSS=VSS
Xi_0_557 AOI22_X1 $PINS ZN=n_0_475 A1=n_0_535 A2=a[29] B1=n_0_534 B2=a[28]
+ VDD=VDD VSS=VSS
Xi_0_556 NAND2_X1 $PINS ZN=n_0_474 A1=b[28] A2=n_0_504 VDD=VDD VSS=VSS
Xi_0_555 AOI22_X1 $PINS ZN=n_0_473 A1=n_0_532 A2=a[26] B1=b[26] B2=n_0_502
+ VDD=VDD VSS=VSS
Xi_0_554 AOI22_X1 $PINS ZN=n_0_472 A1=n_0_531 A2=a[25] B1=b[25] B2=n_0_501
+ VDD=VDD VSS=VSS
Xi_0_553 NOR4_X1 $PINS ZN=n_0_471 A1=a[26] A2=a[24] A3=a[30] A4=a[27] VDD=VDD
+ VSS=VSS
Xi_0_552 NAND4_X1 $PINS ZN=n_0_470 A1=n_0_505 A2=n_0_504 A3=n_0_501 A4=n_0_471
+ VDD=VDD VSS=VSS
Xi_0_551 NAND2_X1 $PINS ZN=n_0_469 A1=n_0_499 A2=n_0_470 VDD=VDD VSS=VSS
Xi_0_550 NOR4_X1 $PINS ZN=n_0_468 A1=b[30] A2=b[27] A3=b[26] A4=b[24] VDD=VDD
+ VSS=VSS
Xi_0_549 NAND4_X1 $PINS ZN=n_0_467 A1=n_0_535 A2=n_0_534 A3=n_0_531 A4=n_0_468
+ VDD=VDD VSS=VSS
Xi_0_548 NAND2_X1 $PINS ZN=n_0_466 A1=n_0_529 A2=n_0_467 VDD=VDD VSS=VSS
Xi_0_547 NAND3_X1 $PINS ZN=n_0_465 A1=n_0_529 A2=n_0_467 A3=n_0_469 VDD=VDD
+ VSS=VSS
Xi_0_546 AOI22_X1 $PINS ZN=n_0_464 A1=n_0_530 A2=a[24] B1=b[24] B2=n_0_500
+ VDD=VDD VSS=VSS
Xi_0_545 INV_X1 $PINS ZN=n_0_463 A=n_0_464 VDD=VDD VSS=VSS
Xi_0_544 OAI22_X1 $PINS ZN=n_0_462 A1=b[24] A2=n_0_500 B1=n_0_465 B2=n_0_463
+ VDD=VDD VSS=VSS
Xi_0_543 NAND2_X1 $PINS ZN=n_0_461 A1=n_0_472 A2=n_0_462 VDD=VDD VSS=VSS
Xi_0_542 OAI21_X1 $PINS ZN=n_0_460 A=n_0_461 B1=b[25] B2=n_0_501 VDD=VDD
+ VSS=VSS
Xi_0_541 AOI22_X1 $PINS ZN=n_0_459 A1=n_0_532 A2=a[26] B1=n_0_473 B2=n_0_460
+ VDD=VDD VSS=VSS
Xi_0_540 AOI22_X1 $PINS ZN=n_0_458 A1=n_0_533 A2=a[27] B1=b[27] B2=n_0_503
+ VDD=VDD VSS=VSS
Xi_0_539 INV_X1 $PINS ZN=n_0_457 A=n_0_458 VDD=VDD VSS=VSS
Xi_0_538 OAI22_X1 $PINS ZN=n_0_456 A1=b[27] A2=n_0_503 B1=n_0_459 B2=n_0_457
+ VDD=VDD VSS=VSS
Xi_0_537 NAND2_X1 $PINS ZN=n_0_455 A1=n_0_474 A2=n_0_456 VDD=VDD VSS=VSS
Xi_0_536 NAND2_X1 $PINS ZN=n_0_454 A1=n_0_475 A2=n_0_455 VDD=VDD VSS=VSS
Xi_0_535 NAND2_X1 $PINS ZN=n_0_453 A1=b[29] A2=n_0_505 VDD=VDD VSS=VSS
Xi_0_534 INV_X1 $PINS ZN=n_0_452 A=n_0_453 VDD=VDD VSS=VSS
Xi_0_533 AOI21_X1 $PINS ZN=n_0_451 A=n_0_452 B1=b[30] B2=n_0_506 VDD=VDD
+ VSS=VSS
Xi_0_532 AOI22_X1 $PINS ZN=n_0_450 A1=n_0_536 A2=a[30] B1=n_0_454 B2=n_0_451
+ VDD=VDD VSS=VSS
Xi_0_531 NAND3_X1 $PINS ZN=n_0_449 A1=n_0_499 A2=n_0_470 A3=n_0_466 VDD=VDD
+ VSS=VSS
Xi_0_530 NAND2_X1 $PINS ZN=n_0_448 A1=n_0_465 A2=n_0_449 VDD=VDD VSS=VSS
Xi_0_529 INV_X1 $PINS ZN=n_0_447 A=n_0_448 VDD=VDD VSS=VSS
Xi_0_528 NAND2_X1 $PINS ZN=n_0_446 A1=n_0_476 A2=n_0_453 VDD=VDD VSS=VSS
Xi_0_527 AND2_X1 $PINS ZN=n_0_445 A1=n_0_475 A2=n_0_453 VDD=VDD VSS=VSS
Xi_0_526 AND2_X1 $PINS ZN=n_0_444 A1=n_0_474 A2=n_0_445 VDD=VDD VSS=VSS
Xi_0_525 AOI22_X1 $PINS ZN=n_0_443 A1=n_0_536 A2=a[30] B1=b[30] B2=n_0_506
+ VDD=VDD VSS=VSS
Xi_0_524 INV_X1 $PINS ZN=n_0_442 A=n_0_443 VDD=VDD VSS=VSS
Xi_0_523 AND4_X1 $PINS ZN=n_0_441 A1=n_0_473 A2=n_0_472 A3=n_0_458 A4=n_0_464
+ VDD=VDD VSS=VSS
Xi_0_522 NAND4_X1 $PINS ZN=n_0_440 A1=n_0_447 A2=n_0_441 A3=n_0_444 A4=n_0_443
+ VDD=VDD VSS=VSS
Xi_0_521 INV_X1 $PINS ZN=n_0_439 A=n_0_440 VDD=VDD VSS=VSS
Xi_0_520 NAND2_X2 $PINS ZN=n_0_438 A1=n_0_450 A2=n_0_440 VDD=VDD VSS=VSS
Xi_0_519 INV_X1 $PINS ZN=n_0_437 A=n_0_438 VDD=VDD VSS=VSS
Xi_0_518 OAI22_X1 $PINS ZN=n_55 A1=n_0_535 A2=n_0_438 B1=n_0_505 B2=n_0_437
+ VDD=VDD VSS=VSS
Xi_0_517 AOI22_X1 $PINS ZN=n_54 A1=n_0_534 A2=n_0_437 B1=n_0_504 B2=n_0_438
+ VDD=VDD VSS=VSS
Xi_0_516 AOI22_X1 $PINS ZN=n_53 A1=n_0_503 A2=n_0_438 B1=n_0_533 B2=n_0_437
+ VDD=VDD VSS=VSS
Xi_0_515 OAI22_X1 $PINS ZN=n_52 A1=n_0_532 A2=n_0_438 B1=n_0_502 B2=n_0_437
+ VDD=VDD VSS=VSS
Xi_0_514 OAI22_X1 $PINS ZN=n_51 A1=n_0_531 A2=n_0_438 B1=n_0_501 B2=n_0_437
+ VDD=VDD VSS=VSS
Xi_0_513 AOI22_X1 $PINS ZN=n_50 A1=n_0_530 A2=n_0_437 B1=n_0_500 B2=n_0_438
+ VDD=VDD VSS=VSS
Xi_0_512 AOI22_X1 $PINS ZN=n_0_436 A1=n_0_466 A2=n_0_437 B1=n_0_469 B2=n_0_438
+ VDD=VDD VSS=VSS
Xi_0_511 INV_X1 $PINS ZN=n_49 A=n_0_436 VDD=VDD VSS=VSS
Xi_0_510 OAI211_X1 $PINS ZN=n_0_435 A=n_0_507 B=a[0] C1=n_0_508 C2=a[1] VDD=VDD
+ VSS=VSS
Xi_0_509 AOI22_X1 $PINS ZN=n_0_434 A1=n_0_509 A2=a[2] B1=n_0_508 B2=a[1]
+ VDD=VDD VSS=VSS
Xi_0_508 AOI22_X1 $PINS ZN=n_0_433 A1=b[2] A2=n_0_480 B1=n_0_435 B2=n_0_434
+ VDD=VDD VSS=VSS
Xi_0_507 AOI21_X1 $PINS ZN=n_0_432 A=n_0_433 B1=n_0_510 B2=a[3] VDD=VDD VSS=VSS
Xi_0_506 OAI22_X1 $PINS ZN=n_0_431 A1=n_0_510 A2=a[3] B1=n_0_511 B2=a[4]
+ VDD=VDD VSS=VSS
Xi_0_505 AOI22_X1 $PINS ZN=n_0_430 A1=n_0_512 A2=a[5] B1=n_0_513 B2=a[6]
+ VDD=VDD VSS=VSS
Xi_0_504 OAI221_X1 $PINS ZN=n_0_429 A=n_0_430 B1=n_0_432 B2=n_0_431 C1=b[4]
+ C2=n_0_481 VDD=VDD VSS=VSS
Xi_0_503 AOI211_X1 $PINS ZN=n_0_428 A=n_0_512 B=a[5] C1=n_0_513 C2=a[6] VDD=VDD
+ VSS=VSS
Xi_0_502 AOI221_X1 $PINS ZN=n_0_427 A=n_0_428 B1=b[7] B2=n_0_483 C1=b[6]
+ C2=n_0_482 VDD=VDD VSS=VSS
Xi_0_501 AOI222_X1 $PINS ZN=n_0_426 A1=n_0_514 A2=a[7] B1=n_0_515 B2=a[8]
+ C1=n_0_429 C2=n_0_427 VDD=VDD VSS=VSS
Xi_0_500 AOI221_X1 $PINS ZN=n_0_425 A=n_0_426 B1=b[9] B2=n_0_485 C1=b[8]
+ C2=n_0_484 VDD=VDD VSS=VSS
Xi_0_499 AOI221_X1 $PINS ZN=n_0_424 A=n_0_425 B1=n_0_516 B2=a[9] C1=n_0_517
+ C2=a[10] VDD=VDD VSS=VSS
Xi_0_498 INV_X1 $PINS ZN=n_0_423 A=n_0_424 VDD=VDD VSS=VSS
Xi_0_497 AOI22_X1 $PINS ZN=n_0_422 A1=b[11] A2=n_0_487 B1=b[10] B2=n_0_486
+ VDD=VDD VSS=VSS
Xi_0_496 AOI22_X1 $PINS ZN=n_0_421 A1=n_0_423 A2=n_0_422 B1=n_0_518 B2=a[11]
+ VDD=VDD VSS=VSS
Xi_0_495 AOI21_X1 $PINS ZN=n_0_420 A=n_0_421 B1=b[12] B2=n_0_488 VDD=VDD
+ VSS=VSS
Xi_0_494 AOI21_X1 $PINS ZN=n_0_419 A=n_0_420 B1=n_0_519 B2=a[12] VDD=VDD
+ VSS=VSS
Xi_0_493 OAI221_X1 $PINS ZN=n_0_418 A=n_0_419 B1=b[13] B2=n_0_489 C1=b[14]
+ C2=n_0_490 VDD=VDD VSS=VSS
Xi_0_492 AOI211_X1 $PINS ZN=n_0_417 A=n_0_520 B=a[13] C1=n_0_521 C2=a[14]
+ VDD=VDD VSS=VSS
Xi_0_491 AOI221_X1 $PINS ZN=n_0_416 A=n_0_417 B1=b[15] B2=n_0_491 C1=b[14]
+ C2=n_0_490 VDD=VDD VSS=VSS
Xi_0_490 AOI22_X1 $PINS ZN=n_0_415 A1=n_0_522 A2=a[15] B1=n_0_418 B2=n_0_416
+ VDD=VDD VSS=VSS
Xi_0_489 AOI21_X1 $PINS ZN=n_0_414 A=n_0_415 B1=b[16] B2=n_0_492 VDD=VDD
+ VSS=VSS
Xi_0_488 AOI21_X1 $PINS ZN=n_0_413 A=n_0_414 B1=n_0_524 B2=a[18] VDD=VDD
+ VSS=VSS
Xi_0_487 OAI221_X1 $PINS ZN=n_0_412 A=n_0_413 B1=b[16] B2=n_0_492 C1=b[17]
+ C2=n_0_493 VDD=VDD VSS=VSS
Xi_0_486 AOI211_X1 $PINS ZN=n_0_411 A=n_0_523 B=a[17] C1=n_0_524 C2=a[18]
+ VDD=VDD VSS=VSS
Xi_0_485 AOI221_X1 $PINS ZN=n_0_410 A=n_0_411 B1=b[19] B2=n_0_495 C1=b[18]
+ C2=n_0_494 VDD=VDD VSS=VSS
Xi_0_484 AOI222_X1 $PINS ZN=n_0_409 A1=n_0_526 A2=a[20] B1=n_0_525 B2=a[19]
+ C1=n_0_412 C2=n_0_410 VDD=VDD VSS=VSS
Xi_0_483 AOI221_X1 $PINS ZN=n_0_408 A=n_0_409 B1=b[20] B2=n_0_496 C1=b[21]
+ C2=n_0_497 VDD=VDD VSS=VSS
Xi_0_482 AOI221_X1 $PINS ZN=n_0_407 A=n_0_408 B1=n_0_527 B2=a[21] C1=n_0_528
+ C2=a[22] VDD=VDD VSS=VSS
Xi_0_481 INV_X1 $PINS ZN=n_0_406 A=n_0_407 VDD=VDD VSS=VSS
Xi_0_480 NOR2_X1 $PINS ZN=n_0_405 A1=a[23] A2=n_0_470 VDD=VDD VSS=VSS
Xi_0_479 INV_X1 $PINS ZN=n_0_404 A=n_0_405 VDD=VDD VSS=VSS
Xi_0_478 NOR2_X1 $PINS ZN=n_0_403 A1=b[23] A2=n_0_467 VDD=VDD VSS=VSS
Xi_0_477 INV_X1 $PINS ZN=n_0_402 A=n_0_403 VDD=VDD VSS=VSS
Xi_0_476 AOI22_X1 $PINS ZN=n_0_401 A1=n_0_405 A2=n_0_402 B1=b[22] B2=n_0_498
+ VDD=VDD VSS=VSS
Xi_0_475 AOI22_X1 $PINS ZN=n_0_400 A1=n_0_406 A2=n_0_401 B1=n_0_404 B2=n_0_403
+ VDD=VDD VSS=VSS
Xi_0_474 XNOR2_X1 $PINS ZN=n_0_399 A=b[31] B=a[31] VDD=VDD VSS=VSS
Xi_0_473 INV_X1 $PINS ZN=n_0_398 A=n_0_399 VDD=VDD VSS=VSS
Xi_0_472 NAND3_X1 $PINS ZN=n_0_397 A1=n_0_439 A2=n_0_398 A3=n_0_400 VDD=VDD
+ VSS=VSS
Xi_0_471 INV_X1 $PINS ZN=n_0_396 A=n_0_397 VDD=VDD VSS=VSS
Xi_0_470 NAND2_X1 $PINS ZN=n_0_395 A1=n_0_438 A2=n_0_397 VDD=VDD VSS=VSS
Xi_0_469 INV_X1 $PINS ZN=n_0_394 A=n_0_395 VDD=VDD VSS=VSS
Xi_0_468 AOI22_X1 $PINS ZN=n_0_393 A1=a[31] A2=n_0_394 B1=b[31] B2=n_0_395
+ VDD=VDD VSS=VSS
Xi_0_467 INV_X1 $PINS ZN=out[31] A=n_0_393 VDD=VDD VSS=VSS
Xi_0_466 OAI21_X1 $PINS ZN=n_0_392 A=n_0_399 B1=CLA_COUT B2=n_0_439 VDD=VDD
+ VSS=VSS
Xi_0_465 INV_X2 $PINS ZN=n_0_391 A=n_0_392 VDD=VDD VSS=VSS
Xi_0_464 NOR2_X1 $PINS ZN=n_48 A1=CLA_SUM[23] A2=n_0_391 VDD=VDD VSS=VSS
Xi_0_463 AOI221_X1 $PINS ZN=n_0_390 A=n_0_392 B1=n_0_478 B2=n_0_477 C1=n_0_5
+ C2=n_56 VDD=VDD VSS=VSS
Xi_0_462 AND2_X2 $PINS ZN=n_0_389 A1=CLA_SUM[23] A2=n_0_392 VDD=VDD VSS=VSS
Xi_0_461 AOI221_X1 $PINS ZN=n_0_388 A=n_0_390 B1=o_e[7] B2=hfn_ipo_n5 C1=n_56
+ C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_460 INV_X1 $PINS ZN=out[30] A=n_0_388 VDD=VDD VSS=VSS
Xi_0_459 AOI222_X1 $PINS ZN=n_0_387 A1=o_e[6] A2=hfn_ipo_n5 B1=n_0_11
+ B2=n_0_391 C1=n_55 C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_458 INV_X1 $PINS ZN=out[29] A=n_0_387 VDD=VDD VSS=VSS
Xi_0_457 AOI222_X1 $PINS ZN=n_0_386 A1=o_e[5] A2=hfn_ipo_n5 B1=n_0_10
+ B2=n_0_391 C1=n_54 C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_456 INV_X1 $PINS ZN=out[28] A=n_0_386 VDD=VDD VSS=VSS
Xi_0_455 AOI222_X1 $PINS ZN=n_0_385 A1=n_0_9 A2=n_0_391 B1=o_e[4] B2=hfn_ipo_n5
+ C1=n_53 C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_454 INV_X1 $PINS ZN=out[27] A=n_0_385 VDD=VDD VSS=VSS
Xi_0_453 AOI222_X1 $PINS ZN=n_0_384 A1=o_e[3] A2=hfn_ipo_n5 B1=n_0_8 B2=n_0_391
+ C1=n_52 C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_452 INV_X1 $PINS ZN=out[26] A=n_0_384 VDD=VDD VSS=VSS
Xi_0_451 AOI222_X1 $PINS ZN=n_0_383 A1=o_e[2] A2=hfn_ipo_n5 B1=n_0_7 B2=n_0_391
+ C1=n_51 C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_450 INV_X1 $PINS ZN=out[25] A=n_0_383 VDD=VDD VSS=VSS
Xi_0_449 AOI222_X1 $PINS ZN=n_0_382 A1=o_e[1] A2=hfn_ipo_n5 B1=n_0_6 B2=n_0_391
+ C1=n_50 C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_448 INV_X1 $PINS ZN=out[24] A=n_0_382 VDD=VDD VSS=VSS
Xi_0_447 AOI22_X1 $PINS ZN=n_0_381 A1=o_e[0] A2=hfn_ipo_n5 B1=n_49 B2=n_0_389
+ VDD=VDD VSS=VSS
Xi_0_446 OAI21_X1 $PINS ZN=out[23] A=n_0_381 B1=n_49 B2=n_0_392 VDD=VDD VSS=VSS
Xi_0_445 AOI21_X1 $PINS ZN=n_0_380 A=CLA_SUM[23] B1=o_m[22] B2=n_0_392 VDD=VDD
+ VSS=VSS
Xi_0_444 AOI21_X1 $PINS ZN=out[22] A=n_0_380 B1=n_0_479 B2=n_0_389 VDD=VDD
+ VSS=VSS
Xi_0_443 AOI222_X1 $PINS ZN=n_0_379 A1=o_m[21] A2=hfn_ipo_n5 B1=CLA_SUM[22]
+ B2=n_0_391 C1=CLA_SUM[21] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_442 INV_X1 $PINS ZN=out[21] A=n_0_379 VDD=VDD VSS=VSS
Xi_0_441 AOI222_X1 $PINS ZN=n_0_378 A1=o_m[20] A2=hfn_ipo_n5 B1=CLA_SUM[21]
+ B2=n_0_391 C1=CLA_SUM[20] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_440 INV_X1 $PINS ZN=out[20] A=n_0_378 VDD=VDD VSS=VSS
Xi_0_439 AOI222_X1 $PINS ZN=n_0_377 A1=o_m[19] A2=hfn_ipo_n5 B1=CLA_SUM[20]
+ B2=n_0_391 C1=CLA_SUM[19] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_438 INV_X1 $PINS ZN=out[19] A=n_0_377 VDD=VDD VSS=VSS
Xi_0_437 AOI222_X2 $PINS ZN=n_0_376 A1=o_m[18] A2=hfn_ipo_n5 B1=CLA_SUM[19]
+ B2=n_0_391 C1=CLA_SUM[18] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_436 INV_X1 $PINS ZN=out[18] A=n_0_376 VDD=VDD VSS=VSS
Xi_0_435 AOI222_X1 $PINS ZN=n_0_375 A1=o_m[17] A2=hfn_ipo_n5 B1=CLA_SUM[18]
+ B2=n_0_391 C1=CLA_SUM[17] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_434 INV_X1 $PINS ZN=out[17] A=n_0_375 VDD=VDD VSS=VSS
Xi_0_433 AOI222_X1 $PINS ZN=n_0_374 A1=o_m[16] A2=hfn_ipo_n6 B1=CLA_SUM[17]
+ B2=n_0_391 C1=CLA_SUM[16] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_432 INV_X1 $PINS ZN=out[16] A=n_0_374 VDD=VDD VSS=VSS
Xi_0_431 AOI222_X1 $PINS ZN=n_0_373 A1=o_m[15] A2=hfn_ipo_n6 B1=CLA_SUM[16]
+ B2=n_0_391 C1=CLA_SUM[15] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_430 INV_X1 $PINS ZN=out[15] A=n_0_373 VDD=VDD VSS=VSS
Xi_0_429 AOI222_X1 $PINS ZN=n_0_372 A1=o_m[14] A2=hfn_ipo_n5 B1=CLA_SUM[15]
+ B2=n_0_391 C1=CLA_SUM[14] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_428 INV_X1 $PINS ZN=out[14] A=n_0_372 VDD=VDD VSS=VSS
Xi_0_427 AOI222_X1 $PINS ZN=n_0_371 A1=o_m[13] A2=hfn_ipo_n6 B1=CLA_SUM[14]
+ B2=n_0_391 C1=CLA_SUM[13] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_426 INV_X1 $PINS ZN=out[13] A=n_0_371 VDD=VDD VSS=VSS
Xi_0_425 AOI222_X1 $PINS ZN=n_0_370 A1=o_m[12] A2=hfn_ipo_n6 B1=CLA_SUM[13]
+ B2=n_0_391 C1=CLA_SUM[12] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_424 INV_X1 $PINS ZN=out[12] A=n_0_370 VDD=VDD VSS=VSS
Xi_0_423 AOI222_X1 $PINS ZN=n_0_369 A1=o_m[11] A2=hfn_ipo_n6 B1=CLA_SUM[12]
+ B2=n_0_391 C1=CLA_SUM[11] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_422 INV_X1 $PINS ZN=out[11] A=n_0_369 VDD=VDD VSS=VSS
Xi_0_421 AOI222_X1 $PINS ZN=n_0_368 A1=o_m[10] A2=hfn_ipo_n6 B1=CLA_SUM[11]
+ B2=n_0_391 C1=CLA_SUM[10] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_420 INV_X1 $PINS ZN=out[10] A=n_0_368 VDD=VDD VSS=VSS
Xi_0_419 AOI222_X1 $PINS ZN=n_0_367 A1=o_m[9] A2=hfn_ipo_n6 B1=CLA_SUM[10]
+ B2=n_0_391 C1=CLA_SUM[9] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_418 INV_X1 $PINS ZN=out[9] A=n_0_367 VDD=VDD VSS=VSS
Xi_0_417 AOI222_X1 $PINS ZN=n_0_366 A1=o_m[8] A2=hfn_ipo_n6 B1=CLA_SUM[9]
+ B2=n_0_391 C1=CLA_SUM[8] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_416 INV_X1 $PINS ZN=out[8] A=n_0_366 VDD=VDD VSS=VSS
Xi_0_415 AOI222_X1 $PINS ZN=n_0_365 A1=o_m[7] A2=hfn_ipo_n6 B1=CLA_SUM[8]
+ B2=n_0_391 C1=CLA_SUM[7] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_414 INV_X1 $PINS ZN=out[7] A=n_0_365 VDD=VDD VSS=VSS
Xi_0_413 AOI222_X1 $PINS ZN=n_0_364 A1=o_m[6] A2=hfn_ipo_n6 B1=CLA_SUM[7]
+ B2=n_0_391 C1=CLA_SUM[6] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_412 INV_X1 $PINS ZN=out[6] A=n_0_364 VDD=VDD VSS=VSS
Xi_0_411 AOI222_X1 $PINS ZN=n_0_363 A1=o_m[5] A2=hfn_ipo_n6 B1=CLA_SUM[6]
+ B2=n_0_391 C1=CLA_SUM[5] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_410 INV_X1 $PINS ZN=out[5] A=n_0_363 VDD=VDD VSS=VSS
Xi_0_409 AOI222_X1 $PINS ZN=n_0_362 A1=o_m[4] A2=hfn_ipo_n6 B1=CLA_SUM[5]
+ B2=n_0_391 C1=CLA_SUM[4] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_408 INV_X1 $PINS ZN=out[4] A=n_0_362 VDD=VDD VSS=VSS
Xi_0_407 AOI222_X1 $PINS ZN=n_0_361 A1=o_m[3] A2=hfn_ipo_n6 B1=CLA_SUM[4]
+ B2=n_0_391 C1=CLA_SUM[3] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_406 INV_X1 $PINS ZN=out[3] A=n_0_361 VDD=VDD VSS=VSS
Xi_0_405 AOI222_X1 $PINS ZN=n_0_360 A1=o_m[2] A2=hfn_ipo_n6 B1=CLA_SUM[3]
+ B2=n_0_391 C1=CLA_SUM[2] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_404 INV_X1 $PINS ZN=out[2] A=n_0_360 VDD=VDD VSS=VSS
Xi_0_403 AOI222_X1 $PINS ZN=n_0_359 A1=o_m[1] A2=hfn_ipo_n6 B1=CLA_SUM[2]
+ B2=n_0_391 C1=CLA_SUM[1] C2=n_0_389 VDD=VDD VSS=VSS
Xi_0_402 INV_X1 $PINS ZN=out[1] A=n_0_359 VDD=VDD VSS=VSS
Xi_0_401 AOI22_X1 $PINS ZN=n_0_358 A1=CLA_SUM[0] A2=n_0_389 B1=CLA_SUM[1]
+ B2=n_0_391 VDD=VDD VSS=VSS
Xi_0_400 INV_X1 $PINS ZN=out[0] A=n_0_358 VDD=VDD VSS=VSS
Xi_0_399 NOR2_X1 $PINS ZN=n_0_357 A1=n_0_400 A2=n_0_399 VDD=VDD VSS=VSS
Xi_0_398 NAND2_X1 $PINS ZN=n_0_356 A1=n_0_439 A2=n_0_357 VDD=VDD VSS=VSS
Xi_0_397 INV_X1 $PINS ZN=n_0_355 A=n_0_356 VDD=VDD VSS=VSS
Xi_0_396 NAND2_X1 $PINS ZN=n_0_354 A1=n_0_437 A2=n_0_398 VDD=VDD VSS=VSS
Xi_0_395 INV_X1 $PINS ZN=n_0_353 A=n_0_354 VDD=VDD VSS=VSS
Xi_0_394 NOR2_X2 $PINS ZN=n_0_352 A1=n_0_450 A2=n_0_399 VDD=VDD VSS=VSS
Xi_0_393 INV_X1 $PINS ZN=n_0_351 A=n_0_352 VDD=VDD VSS=VSS
Xi_0_392 NOR2_X4 $PINS ZN=n_0_350 A1=n_0_440 A2=n_0_357 VDD=VDD VSS=VSS
Xi_0_391 AOI211_X1 $PINS ZN=n_0_349 A=n_0_353 B=n_0_352 C1=n_0_402 C2=n_0_350
+ VDD=VDD VSS=VSS
Xi_0_390 OAI21_X1 $PINS ZN=n_47 A=n_0_349 B1=n_0_402 B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_389 OAI22_X1 $PINS ZN=n_0_348 A1=n_0_530 A2=a[24] B1=n_0_463 B2=n_0_449
+ VDD=VDD VSS=VSS
Xi_0_388 NAND2_X1 $PINS ZN=n_0_347 A1=n_0_472 A2=n_0_348 VDD=VDD VSS=VSS
Xi_0_387 OAI21_X1 $PINS ZN=n_0_346 A=n_0_347 B1=n_0_531 B2=a[25] VDD=VDD
+ VSS=VSS
Xi_0_386 NAND2_X1 $PINS ZN=n_0_345 A1=n_0_473 A2=n_0_346 VDD=VDD VSS=VSS
Xi_0_385 OAI21_X1 $PINS ZN=n_0_344 A=n_0_345 B1=n_0_532 B2=a[26] VDD=VDD
+ VSS=VSS
Xi_0_384 AOI22_X1 $PINS ZN=n_0_343 A1=b[27] A2=n_0_503 B1=n_0_458 B2=n_0_344
+ VDD=VDD VSS=VSS
Xi_0_383 NAND2_X1 $PINS ZN=n_0_342 A1=n_0_444 A2=n_0_343 VDD=VDD VSS=VSS
Xi_0_382 AOI21_X1 $PINS ZN=n_0_341 A=n_0_452 B1=n_0_475 B2=n_0_342 VDD=VDD
+ VSS=VSS
Xi_0_381 AOI21_X1 $PINS ZN=n_0_340 A=n_0_343 B1=n_0_474 B2=n_0_446 VDD=VDD
+ VSS=VSS
Xi_0_380 INV_X1 $PINS ZN=n_0_339 A=n_0_340 VDD=VDD VSS=VSS
Xi_0_379 OAI21_X1 $PINS ZN=n_0_338 A=n_0_342 B1=n_0_445 B2=n_0_339 VDD=VDD
+ VSS=VSS
Xi_0_378 OAI21_X1 $PINS ZN=n_0_337 A=n_0_338 B1=n_0_442 B2=n_0_341 VDD=VDD
+ VSS=VSS
Xi_0_377 AOI21_X1 $PINS ZN=n_0_336 A=n_0_337 B1=n_0_442 B2=n_0_341 VDD=VDD
+ VSS=VSS
Xi_0_376 OAI21_X4 $PINS ZN=n_0_335 A=n_0_347 B1=n_0_472 B2=n_0_348 VDD=VDD
+ VSS=VSS
Xi_0_375 INV_X1 $PINS ZN=n_0_334 A=n_0_335 VDD=VDD VSS=VSS
Xi_0_374 OAI21_X1 $PINS ZN=n_0_333 A=n_0_345 B1=n_0_473 B2=n_0_346 VDD=VDD
+ VSS=VSS
Xi_0_373 XNOR2_X1 $PINS ZN=n_0_332 A=n_0_457 B=n_0_344 VDD=VDD VSS=VSS
Xi_0_372 INV_X1 $PINS ZN=n_0_331 A=n_0_332 VDD=VDD VSS=VSS
Xi_0_371 NOR2_X2 $PINS ZN=n_0_330 A1=n_0_333 A2=n_0_331 VDD=VDD VSS=VSS
Xi_0_370 NOR3_X1 $PINS ZN=n_0_329 A1=n_0_333 A2=n_0_331 A3=n_0_335 VDD=VDD
+ VSS=VSS
Xi_0_369 NAND2_X1 $PINS ZN=n_0_328 A1=n_0_336 A2=n_0_329 VDD=VDD VSS=VSS
Xi_0_368 XNOR2_X2 $PINS ZN=n_0_327 A=n_0_464 B=n_0_449 VDD=VDD VSS=VSS
Xi_0_367 INV_X2 $PINS ZN=n_0_326 A=n_0_327 VDD=VDD VSS=VSS
Xi_0_366 OAI21_X1 $PINS ZN=n_0_325 A=n_0_327 B1=n_0_469 B2=n_0_402 VDD=VDD
+ VSS=VSS
Xi_0_365 AOI211_X1 $PINS ZN=n_0_324 A=n_0_328 B=n_0_325 C1=n_0_528 C2=n_0_447
+ VDD=VDD VSS=VSS
Xi_0_364 OAI21_X2 $PINS ZN=n_0_323 A=n_0_461 B1=n_0_472 B2=n_0_462 VDD=VDD
+ VSS=VSS
Xi_0_363 INV_X1 $PINS ZN=n_0_322 A=n_0_323 VDD=VDD VSS=VSS
Xi_0_362 XNOR2_X1 $PINS ZN=n_0_321 A=n_0_473 B=n_0_460 VDD=VDD VSS=VSS
Xi_0_361 INV_X1 $PINS ZN=n_0_320 A=n_0_321 VDD=VDD VSS=VSS
Xi_0_360 XNOR2_X1 $PINS ZN=n_0_319 A=n_0_459 B=n_0_458 VDD=VDD VSS=VSS
Xi_0_359 INV_X1 $PINS ZN=n_0_318 A=n_0_319 VDD=VDD VSS=VSS
Xi_0_358 NOR2_X1 $PINS ZN=n_0_317 A1=n_0_321 A2=n_0_318 VDD=VDD VSS=VSS
Xi_0_357 NOR3_X1 $PINS ZN=n_0_316 A1=n_0_321 A2=n_0_318 A3=n_0_323 VDD=VDD
+ VSS=VSS
Xi_0_356 NOR2_X1 $PINS ZN=n_0_315 A1=n_0_452 A2=n_0_442 VDD=VDD VSS=VSS
Xi_0_355 OAI22_X1 $PINS ZN=n_0_314 A1=b[28] A2=n_0_504 B1=n_0_452 B2=n_0_442
+ VDD=VDD VSS=VSS
Xi_0_354 AOI22_X1 $PINS ZN=n_0_313 A1=n_0_456 A2=n_0_314 B1=n_0_474 B2=n_0_315
+ VDD=VDD VSS=VSS
Xi_0_353 AOI221_X1 $PINS ZN=n_0_312 A=n_0_313 B1=n_0_476 B2=n_0_442 C1=n_0_454
+ C2=n_0_315 VDD=VDD VSS=VSS
Xi_0_352 NAND2_X1 $PINS ZN=n_0_311 A1=n_0_316 A2=n_0_312 VDD=VDD VSS=VSS
Xi_0_351 XNOR2_X2 $PINS ZN=n_0_310 A=n_0_465 B=n_0_464 VDD=VDD VSS=VSS
Xi_0_350 INV_X1 $PINS ZN=n_0_309 A=n_0_310 VDD=VDD VSS=VSS
Xi_0_349 OAI21_X1 $PINS ZN=n_0_308 A=n_0_310 B1=n_0_466 B2=n_0_404 VDD=VDD
+ VSS=VSS
Xi_0_348 AOI211_X1 $PINS ZN=n_0_307 A=n_0_311 B=n_0_308 C1=n_0_498 C2=n_0_447
+ VDD=VDD VSS=VSS
Xi_0_347 NAND2_X1 $PINS ZN=n_0_306 A1=n_0_437 A2=n_0_399 VDD=VDD VSS=VSS
Xi_0_346 INV_X1 $PINS ZN=n_0_305 A=n_0_306 VDD=VDD VSS=VSS
Xi_0_345 OAI22_X1 $PINS ZN=n_0_304 A1=n_0_351 A2=n_0_324 B1=n_0_354 B2=n_0_307
+ VDD=VDD VSS=VSS
Xi_0_344 AOI21_X1 $PINS ZN=n_0_303 A=n_0_304 B1=n_0_307 B2=n_0_305 VDD=VDD
+ VSS=VSS
Xi_0_343 NOR2_X1 $PINS ZN=n_0_302 A1=n_0_450 A2=n_0_398 VDD=VDD VSS=VSS
Xi_0_342 INV_X1 $PINS ZN=n_0_301 A=n_0_302 VDD=VDD VSS=VSS
Xi_0_341 AOI22_X1 $PINS ZN=n_0_300 A1=b[22] A2=n_0_350 B1=n_0_324 B2=n_0_302
+ VDD=VDD VSS=VSS
Xi_0_340 OAI211_X1 $PINS ZN=n_46 A=n_0_300 B=n_0_303 C1=b[22] C2=n_0_356
+ VDD=VDD VSS=VSS
Xi_0_339 AOI22_X1 $PINS ZN=n_0_299 A1=n_0_402 A2=n_0_326 B1=b[21] B2=n_0_327
+ VDD=VDD VSS=VSS
Xi_0_338 AOI21_X1 $PINS ZN=n_0_298 A=n_0_447 B1=b[22] B2=n_0_327 VDD=VDD
+ VSS=VSS
Xi_0_337 AOI211_X1 $PINS ZN=n_0_297 A=n_0_298 B=n_0_328 C1=n_0_447 C2=n_0_299
+ VDD=VDD VSS=VSS
Xi_0_336 OAI22_X1 $PINS ZN=n_0_296 A1=a[21] A2=n_0_309 B1=n_0_404 B2=n_0_310
+ VDD=VDD VSS=VSS
Xi_0_335 AOI21_X1 $PINS ZN=n_0_295 A=n_0_447 B1=a[22] B2=n_0_310 VDD=VDD
+ VSS=VSS
Xi_0_334 AOI211_X1 $PINS ZN=n_0_294 A=n_0_295 B=n_0_311 C1=n_0_447 C2=n_0_296
+ VDD=VDD VSS=VSS
Xi_0_333 INV_X1 $PINS ZN=n_0_293 A=n_0_294 VDD=VDD VSS=VSS
Xi_0_332 AOI22_X1 $PINS ZN=n_0_292 A1=n_0_354 A2=n_0_293 B1=n_0_306 B2=n_0_294
+ VDD=VDD VSS=VSS
Xi_0_331 AOI21_X1 $PINS ZN=n_0_291 A=n_0_292 B1=n_0_302 B2=n_0_297 VDD=VDD
+ VSS=VSS
Xi_0_330 OAI21_X1 $PINS ZN=n_0_290 A=n_0_291 B1=n_0_351 B2=n_0_297 VDD=VDD
+ VSS=VSS
Xi_0_329 AOI21_X1 $PINS ZN=n_0_289 A=n_0_290 B1=b[21] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_328 OAI21_X1 $PINS ZN=n_45 A=n_0_289 B1=b[21] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_327 AOI22_X1 $PINS ZN=n_0_288 A1=b[22] A2=n_0_326 B1=b[20] B2=n_0_327
+ VDD=VDD VSS=VSS
Xi_0_326 AOI221_X1 $PINS ZN=n_0_287 A=n_0_328 B1=n_0_447 B2=n_0_288 C1=n_0_448
+ C2=n_0_299 VDD=VDD VSS=VSS
Xi_0_325 AOI22_X1 $PINS ZN=n_0_286 A1=a[20] A2=n_0_310 B1=a[22] B2=n_0_309
+ VDD=VDD VSS=VSS
Xi_0_324 AOI221_X1 $PINS ZN=n_0_285 A=n_0_311 B1=n_0_448 B2=n_0_296 C1=n_0_447
+ C2=n_0_286 VDD=VDD VSS=VSS
Xi_0_323 OAI22_X1 $PINS ZN=n_0_284 A1=n_0_351 A2=n_0_287 B1=n_0_354 B2=n_0_285
+ VDD=VDD VSS=VSS
Xi_0_322 AOI21_X1 $PINS ZN=n_0_283 A=n_0_284 B1=n_0_302 B2=n_0_287 VDD=VDD
+ VSS=VSS
Xi_0_321 AOI22_X1 $PINS ZN=n_0_282 A1=b[20] A2=n_0_350 B1=n_0_305 B2=n_0_285
+ VDD=VDD VSS=VSS
Xi_0_320 OAI211_X1 $PINS ZN=n_44 A=n_0_283 B=n_0_282 C1=b[20] C2=n_0_356
+ VDD=VDD VSS=VSS
Xi_0_319 NAND2_X1 $PINS ZN=n_0_281 A1=n_0_447 A2=n_0_336 VDD=VDD VSS=VSS
Xi_0_318 INV_X1 $PINS ZN=n_0_280 A=n_0_281 VDD=VDD VSS=VSS
Xi_0_317 OAI21_X1 $PINS ZN=n_0_279 A=n_0_281 B1=n_0_328 B2=n_0_288 VDD=VDD
+ VSS=VSS
Xi_0_316 NOR3_X2 $PINS ZN=n_0_278 A1=n_0_333 A2=n_0_331 A3=n_0_334 VDD=VDD
+ VSS=VSS
Xi_0_315 AOI22_X1 $PINS ZN=n_0_277 A1=n_0_402 A2=n_0_278 B1=b[19] B2=n_0_329
+ VDD=VDD VSS=VSS
Xi_0_314 NAND2_X1 $PINS ZN=n_0_276 A1=n_0_329 A2=n_0_326 VDD=VDD VSS=VSS
Xi_0_313 OAI22_X1 $PINS ZN=n_0_275 A1=n_0_326 A2=n_0_277 B1=n_0_527 B2=n_0_276
+ VDD=VDD VSS=VSS
Xi_0_312 OAI21_X1 $PINS ZN=n_0_274 A=n_0_279 B1=n_0_448 B2=n_0_275 VDD=VDD
+ VSS=VSS
Xi_0_311 INV_X1 $PINS ZN=n_0_273 A=n_0_274 VDD=VDD VSS=VSS
Xi_0_310 NAND2_X1 $PINS ZN=n_0_272 A1=n_0_447 A2=n_0_312 VDD=VDD VSS=VSS
Xi_0_309 INV_X1 $PINS ZN=n_0_271 A=n_0_272 VDD=VDD VSS=VSS
Xi_0_308 OAI21_X1 $PINS ZN=n_0_270 A=n_0_272 B1=n_0_311 B2=n_0_286 VDD=VDD
+ VSS=VSS
Xi_0_307 NAND2_X1 $PINS ZN=n_0_269 A1=n_0_316 A2=n_0_309 VDD=VDD VSS=VSS
Xi_0_306 NOR3_X1 $PINS ZN=n_0_268 A1=n_0_321 A2=n_0_318 A3=n_0_322 VDD=VDD
+ VSS=VSS
Xi_0_305 AOI22_X1 $PINS ZN=n_0_267 A1=a[19] A2=n_0_316 B1=n_0_404 B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_304 OAI22_X1 $PINS ZN=n_0_266 A1=n_0_497 A2=n_0_269 B1=n_0_309 B2=n_0_267
+ VDD=VDD VSS=VSS
Xi_0_303 OAI21_X1 $PINS ZN=n_0_265 A=n_0_270 B1=n_0_448 B2=n_0_266 VDD=VDD
+ VSS=VSS
Xi_0_302 AOI22_X1 $PINS ZN=n_0_264 A1=n_0_302 A2=n_0_273 B1=n_0_353 B2=n_0_265
+ VDD=VDD VSS=VSS
Xi_0_301 OAI221_X1 $PINS ZN=n_0_263 A=n_0_264 B1=n_0_351 B2=n_0_273 C1=n_0_306
+ C2=n_0_265 VDD=VDD VSS=VSS
Xi_0_300 AOI21_X1 $PINS ZN=n_0_262 A=n_0_263 B1=b[19] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_299 OAI21_X1 $PINS ZN=n_43 A=n_0_262 B1=b[19] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_298 AND2_X1 $PINS ZN=n_0_261 A1=n_0_448 A2=n_0_336 VDD=VDD VSS=VSS
Xi_0_297 AOI22_X1 $PINS ZN=n_0_260 A1=b[18] A2=n_0_329 B1=b[22] B2=n_0_278
+ VDD=VDD VSS=VSS
Xi_0_296 OAI22_X1 $PINS ZN=n_0_259 A1=n_0_326 A2=n_0_260 B1=n_0_526 B2=n_0_276
+ VDD=VDD VSS=VSS
Xi_0_295 AOI22_X1 $PINS ZN=n_0_258 A1=n_0_275 A2=n_0_261 B1=n_0_280 B2=n_0_259
+ VDD=VDD VSS=VSS
Xi_0_294 INV_X1 $PINS ZN=n_0_257 A=n_0_258 VDD=VDD VSS=VSS
Xi_0_293 AOI22_X1 $PINS ZN=n_0_256 A1=a[18] A2=n_0_316 B1=a[22] B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_292 OAI22_X1 $PINS ZN=n_0_255 A1=n_0_309 A2=n_0_256 B1=n_0_496 B2=n_0_269
+ VDD=VDD VSS=VSS
Xi_0_291 AND2_X1 $PINS ZN=n_0_254 A1=n_0_448 A2=n_0_312 VDD=VDD VSS=VSS
Xi_0_290 AOI22_X1 $PINS ZN=n_0_253 A1=n_0_271 A2=n_0_255 B1=n_0_266 B2=n_0_254
+ VDD=VDD VSS=VSS
Xi_0_289 AOI22_X1 $PINS ZN=n_0_252 A1=n_0_352 A2=n_0_258 B1=n_0_302 B2=n_0_257
+ VDD=VDD VSS=VSS
Xi_0_288 AOI222_X1 $PINS ZN=n_0_251 A1=b[18] A2=n_0_350 B1=n_0_353 B2=n_0_253
+ C1=n_0_524 C2=n_0_355 VDD=VDD VSS=VSS
Xi_0_287 OAI211_X1 $PINS ZN=n_42 A=n_0_252 B=n_0_251 C1=n_0_306 C2=n_0_253
+ VDD=VDD VSS=VSS
Xi_0_286 AOI22_X1 $PINS ZN=n_0_250 A1=b[17] A2=n_0_329 B1=b[21] B2=n_0_278
+ VDD=VDD VSS=VSS
Xi_0_285 AOI22_X1 $PINS ZN=n_0_249 A1=n_0_327 A2=n_0_250 B1=n_0_326 B2=n_0_277
+ VDD=VDD VSS=VSS
Xi_0_284 AOI22_X1 $PINS ZN=n_0_248 A1=n_0_280 A2=n_0_249 B1=n_0_261 B2=n_0_259
+ VDD=VDD VSS=VSS
Xi_0_283 INV_X1 $PINS ZN=n_0_247 A=n_0_248 VDD=VDD VSS=VSS
Xi_0_282 AOI22_X1 $PINS ZN=n_0_246 A1=a[17] A2=n_0_316 B1=a[21] B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_281 AOI22_X1 $PINS ZN=n_0_245 A1=n_0_310 A2=n_0_246 B1=n_0_309 B2=n_0_267
+ VDD=VDD VSS=VSS
Xi_0_280 AOI22_X1 $PINS ZN=n_0_244 A1=n_0_271 A2=n_0_245 B1=n_0_255 B2=n_0_254
+ VDD=VDD VSS=VSS
Xi_0_279 AOI22_X1 $PINS ZN=n_0_243 A1=n_0_352 A2=n_0_248 B1=n_0_302 B2=n_0_247
+ VDD=VDD VSS=VSS
Xi_0_278 AOI222_X1 $PINS ZN=n_0_242 A1=b[17] A2=n_0_350 B1=n_0_353 B2=n_0_244
+ C1=n_0_523 C2=n_0_355 VDD=VDD VSS=VSS
Xi_0_277 OAI211_X1 $PINS ZN=n_41 A=n_0_243 B=n_0_242 C1=n_0_306 C2=n_0_244
+ VDD=VDD VSS=VSS
Xi_0_276 AOI22_X1 $PINS ZN=n_0_241 A1=b[16] A2=n_0_329 B1=b[20] B2=n_0_278
+ VDD=VDD VSS=VSS
Xi_0_275 AOI22_X1 $PINS ZN=n_0_240 A1=n_0_327 A2=n_0_241 B1=n_0_326 B2=n_0_260
+ VDD=VDD VSS=VSS
Xi_0_274 AOI22_X1 $PINS ZN=n_0_239 A1=n_0_261 A2=n_0_249 B1=n_0_280 B2=n_0_240
+ VDD=VDD VSS=VSS
Xi_0_273 AOI22_X1 $PINS ZN=n_0_238 A1=a[16] A2=n_0_316 B1=a[20] B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_272 AOI22_X1 $PINS ZN=n_0_237 A1=n_0_310 A2=n_0_238 B1=n_0_309 B2=n_0_256
+ VDD=VDD VSS=VSS
Xi_0_271 AOI22_X1 $PINS ZN=n_0_236 A1=n_0_254 A2=n_0_245 B1=n_0_271 B2=n_0_237
+ VDD=VDD VSS=VSS
Xi_0_270 AOI22_X1 $PINS ZN=n_0_235 A1=b[16] A2=n_0_350 B1=n_0_352 B2=n_0_239
+ VDD=VDD VSS=VSS
Xi_0_269 OAI22_X1 $PINS ZN=n_0_234 A1=n_0_301 A2=n_0_239 B1=n_0_306 B2=n_0_236
+ VDD=VDD VSS=VSS
Xi_0_268 AOI21_X1 $PINS ZN=n_0_233 A=n_0_234 B1=n_0_353 B2=n_0_236 VDD=VDD
+ VSS=VSS
Xi_0_267 OAI211_X1 $PINS ZN=n_40 A=n_0_233 B=n_0_235 C1=b[16] C2=n_0_356
+ VDD=VDD VSS=VSS
Xi_0_266 NOR2_X1 $PINS ZN=n_0_232 A1=n_0_320 A2=n_0_318 VDD=VDD VSS=VSS
Xi_0_265 OAI33_X1 $PINS ZN=n_0_231 A1=n_0_321 A2=n_0_318 A3=n_0_491 B1=n_0_320
+ B2=n_0_318 B3=n_0_405 VDD=VDD VSS=VSS
Xi_0_264 AOI22_X1 $PINS ZN=n_0_230 A1=n_0_322 A2=n_0_231 B1=a[19] B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_263 AOI22_X1 $PINS ZN=n_0_229 A1=n_0_310 A2=n_0_230 B1=n_0_309 B2=n_0_246
+ VDD=VDD VSS=VSS
Xi_0_262 AOI22_X1 $PINS ZN=n_0_228 A1=n_0_254 A2=n_0_237 B1=n_0_271 B2=n_0_229
+ VDD=VDD VSS=VSS
Xi_0_261 NAND2_X1 $PINS ZN=n_0_227 A1=b[19] A2=n_0_278 VDD=VDD VSS=VSS
Xi_0_260 AND2_X1 $PINS ZN=n_0_226 A1=n_0_333 A2=n_0_332 VDD=VDD VSS=VSS
Xi_0_259 AOI22_X1 $PINS ZN=n_0_225 A1=b[15] A2=n_0_330 B1=n_0_402 B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_258 OAI21_X1 $PINS ZN=n_0_224 A=n_0_227 B1=n_0_335 B2=n_0_225 VDD=VDD
+ VSS=VSS
Xi_0_257 NOR2_X1 $PINS ZN=n_0_223 A1=n_0_326 A2=n_0_224 VDD=VDD VSS=VSS
Xi_0_256 AOI21_X1 $PINS ZN=n_0_222 A=n_0_223 B1=n_0_326 B2=n_0_250 VDD=VDD
+ VSS=VSS
Xi_0_255 AOI22_X1 $PINS ZN=n_0_221 A1=n_0_261 A2=n_0_240 B1=n_0_280 B2=n_0_222
+ VDD=VDD VSS=VSS
Xi_0_254 AOI22_X1 $PINS ZN=n_0_220 A1=n_0_353 A2=n_0_228 B1=n_0_352 B2=n_0_221
+ VDD=VDD VSS=VSS
Xi_0_253 OAI221_X1 $PINS ZN=n_0_219 A=n_0_220 B1=n_0_306 B2=n_0_228 C1=n_0_301
+ C2=n_0_221 VDD=VDD VSS=VSS
Xi_0_252 AOI21_X1 $PINS ZN=n_0_218 A=n_0_219 B1=b[15] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_251 OAI21_X1 $PINS ZN=n_39 A=n_0_218 B1=b[15] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_250 OAI33_X1 $PINS ZN=n_0_217 A1=n_0_321 A2=n_0_318 A3=n_0_490 B1=n_0_320
+ B2=n_0_318 B3=n_0_498 VDD=VDD VSS=VSS
Xi_0_249 AOI22_X1 $PINS ZN=n_0_216 A1=n_0_322 A2=n_0_217 B1=a[18] B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_248 AOI22_X1 $PINS ZN=n_0_215 A1=n_0_310 A2=n_0_216 B1=n_0_309 B2=n_0_238
+ VDD=VDD VSS=VSS
Xi_0_247 AOI22_X1 $PINS ZN=n_0_214 A1=n_0_254 A2=n_0_229 B1=n_0_271 B2=n_0_215
+ VDD=VDD VSS=VSS
Xi_0_246 NAND2_X1 $PINS ZN=n_0_213 A1=n_0_353 A2=n_0_214 VDD=VDD VSS=VSS
Xi_0_245 AOI22_X1 $PINS ZN=n_0_212 A1=b[14] A2=n_0_330 B1=b[22] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_244 NOR2_X1 $PINS ZN=n_0_211 A1=n_0_335 A2=n_0_212 VDD=VDD VSS=VSS
Xi_0_243 AOI21_X1 $PINS ZN=n_0_210 A=n_0_211 B1=b[18] B2=n_0_278 VDD=VDD
+ VSS=VSS
Xi_0_242 OAI22_X1 $PINS ZN=n_0_209 A1=n_0_326 A2=n_0_210 B1=n_0_327 B2=n_0_241
+ VDD=VDD VSS=VSS
Xi_0_241 AOI22_X1 $PINS ZN=n_0_208 A1=n_0_280 A2=n_0_209 B1=n_0_261 B2=n_0_222
+ VDD=VDD VSS=VSS
Xi_0_240 OAI221_X1 $PINS ZN=n_0_207 A=n_0_213 B1=n_0_306 B2=n_0_214 C1=n_0_301
+ C2=n_0_208 VDD=VDD VSS=VSS
Xi_0_239 AOI221_X1 $PINS ZN=n_0_206 A=n_0_207 B1=n_0_352 B2=n_0_208 C1=b[14]
+ C2=n_0_350 VDD=VDD VSS=VSS
Xi_0_238 OAI21_X1 $PINS ZN=n_38 A=n_0_206 B1=b[14] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_237 NAND2_X1 $PINS ZN=n_0_205 A1=b[17] A2=n_0_278 VDD=VDD VSS=VSS
Xi_0_236 AOI22_X1 $PINS ZN=n_0_204 A1=b[13] A2=n_0_330 B1=b[21] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_235 OAI21_X1 $PINS ZN=n_0_203 A=n_0_205 B1=n_0_335 B2=n_0_204 VDD=VDD
+ VSS=VSS
Xi_0_234 AOI22_X1 $PINS ZN=n_0_202 A1=n_0_327 A2=n_0_203 B1=n_0_326 B2=n_0_224
+ VDD=VDD VSS=VSS
Xi_0_233 INV_X1 $PINS ZN=n_0_201 A=n_0_202 VDD=VDD VSS=VSS
Xi_0_232 AOI22_X1 $PINS ZN=n_0_200 A1=n_0_261 A2=n_0_209 B1=n_0_280 B2=n_0_201
+ VDD=VDD VSS=VSS
Xi_0_231 OAI33_X1 $PINS ZN=n_0_199 A1=n_0_321 A2=n_0_318 A3=n_0_489 B1=n_0_320
+ B2=n_0_318 B3=n_0_497 VDD=VDD VSS=VSS
Xi_0_230 AOI22_X1 $PINS ZN=n_0_198 A1=n_0_322 A2=n_0_199 B1=a[17] B2=n_0_268
+ VDD=VDD VSS=VSS
Xi_0_229 AOI22_X1 $PINS ZN=n_0_197 A1=n_0_310 A2=n_0_198 B1=n_0_309 B2=n_0_230
+ VDD=VDD VSS=VSS
Xi_0_228 AOI22_X1 $PINS ZN=n_0_196 A1=n_0_271 A2=n_0_197 B1=n_0_254 B2=n_0_215
+ VDD=VDD VSS=VSS
Xi_0_227 AOI22_X1 $PINS ZN=n_0_195 A1=n_0_353 A2=n_0_196 B1=n_0_352 B2=n_0_200
+ VDD=VDD VSS=VSS
Xi_0_226 OAI221_X1 $PINS ZN=n_0_194 A=n_0_195 B1=n_0_301 B2=n_0_200 C1=n_0_306
+ C2=n_0_196 VDD=VDD VSS=VSS
Xi_0_225 AOI21_X1 $PINS ZN=n_0_193 A=n_0_194 B1=b[13] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_224 OAI21_X1 $PINS ZN=n_37 A=n_0_193 B1=b[13] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_223 AOI22_X1 $PINS ZN=n_0_192 A1=b[12] A2=n_0_330 B1=b[20] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_222 INV_X1 $PINS ZN=n_0_191 A=n_0_192 VDD=VDD VSS=VSS
Xi_0_221 AOI22_X1 $PINS ZN=n_0_190 A1=n_0_334 A2=n_0_191 B1=b[16] B2=n_0_278
+ VDD=VDD VSS=VSS
Xi_0_220 AOI22_X1 $PINS ZN=n_0_189 A1=n_0_327 A2=n_0_190 B1=n_0_326 B2=n_0_210
+ VDD=VDD VSS=VSS
Xi_0_219 AOI22_X1 $PINS ZN=n_0_188 A1=n_0_261 A2=n_0_201 B1=n_0_280 B2=n_0_189
+ VDD=VDD VSS=VSS
Xi_0_218 NAND2_X1 $PINS ZN=n_0_187 A1=a[16] A2=n_0_268 VDD=VDD VSS=VSS
Xi_0_217 AOI22_X1 $PINS ZN=n_0_186 A1=a[12] A2=n_0_317 B1=a[20] B2=n_0_232
+ VDD=VDD VSS=VSS
Xi_0_216 OAI21_X1 $PINS ZN=n_0_185 A=n_0_187 B1=n_0_323 B2=n_0_186 VDD=VDD
+ VSS=VSS
Xi_0_215 NOR2_X1 $PINS ZN=n_0_184 A1=n_0_309 A2=n_0_185 VDD=VDD VSS=VSS
Xi_0_214 AOI21_X1 $PINS ZN=n_0_183 A=n_0_184 B1=n_0_309 B2=n_0_216 VDD=VDD
+ VSS=VSS
Xi_0_213 AOI22_X1 $PINS ZN=n_0_182 A1=n_0_254 A2=n_0_197 B1=n_0_271 B2=n_0_183
+ VDD=VDD VSS=VSS
Xi_0_212 AOI22_X1 $PINS ZN=n_0_181 A1=n_0_352 A2=n_0_188 B1=n_0_353 B2=n_0_182
+ VDD=VDD VSS=VSS
Xi_0_211 OAI221_X1 $PINS ZN=n_0_180 A=n_0_181 B1=n_0_306 B2=n_0_182 C1=n_0_301
+ C2=n_0_188 VDD=VDD VSS=VSS
Xi_0_210 AOI21_X1 $PINS ZN=n_0_179 A=n_0_180 B1=b[12] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_209 OAI21_X1 $PINS ZN=n_36 A=n_0_179 B1=b[12] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_208 AOI22_X1 $PINS ZN=n_0_178 A1=a[11] A2=n_0_317 B1=a[19] B2=n_0_232
+ VDD=VDD VSS=VSS
Xi_0_207 NAND2_X1 $PINS ZN=n_0_177 A1=n_0_322 A2=n_0_178 VDD=VDD VSS=VSS
Xi_0_206 OAI21_X1 $PINS ZN=n_0_176 A=n_0_177 B1=n_0_322 B2=n_0_231 VDD=VDD
+ VSS=VSS
Xi_0_205 AOI22_X1 $PINS ZN=n_0_175 A1=n_0_310 A2=n_0_176 B1=n_0_309 B2=n_0_198
+ VDD=VDD VSS=VSS
Xi_0_204 AOI22_X1 $PINS ZN=n_0_174 A1=n_0_271 A2=n_0_175 B1=n_0_254 B2=n_0_183
+ VDD=VDD VSS=VSS
Xi_0_203 AOI22_X1 $PINS ZN=n_0_173 A1=b[11] A2=n_0_330 B1=b[19] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_202 AOI22_X1 $PINS ZN=n_0_172 A1=n_0_334 A2=n_0_173 B1=n_0_335 B2=n_0_225
+ VDD=VDD VSS=VSS
Xi_0_201 INV_X1 $PINS ZN=n_0_171 A=n_0_172 VDD=VDD VSS=VSS
Xi_0_200 NAND2_X1 $PINS ZN=n_0_170 A1=n_0_326 A2=n_0_203 VDD=VDD VSS=VSS
Xi_0_199 OAI21_X1 $PINS ZN=n_0_169 A=n_0_170 B1=n_0_326 B2=n_0_171 VDD=VDD
+ VSS=VSS
Xi_0_198 AOI22_X1 $PINS ZN=n_0_168 A1=n_0_280 A2=n_0_169 B1=n_0_261 B2=n_0_189
+ VDD=VDD VSS=VSS
Xi_0_197 AOI22_X1 $PINS ZN=n_0_167 A1=n_0_352 A2=n_0_168 B1=n_0_353 B2=n_0_174
+ VDD=VDD VSS=VSS
Xi_0_196 OAI221_X1 $PINS ZN=n_0_166 A=n_0_167 B1=n_0_306 B2=n_0_174 C1=n_0_301
+ C2=n_0_168 VDD=VDD VSS=VSS
Xi_0_195 AOI21_X1 $PINS ZN=n_0_165 A=n_0_166 B1=b[11] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_194 OAI21_X1 $PINS ZN=n_35 A=n_0_165 B1=b[11] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_193 AOI22_X1 $PINS ZN=n_0_164 A1=b[10] A2=n_0_330 B1=b[18] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_192 AOI22_X1 $PINS ZN=n_0_163 A1=n_0_334 A2=n_0_164 B1=n_0_335 B2=n_0_212
+ VDD=VDD VSS=VSS
Xi_0_191 INV_X1 $PINS ZN=n_0_162 A=n_0_163 VDD=VDD VSS=VSS
Xi_0_190 AOI22_X1 $PINS ZN=n_0_161 A1=n_0_326 A2=n_0_190 B1=n_0_327 B2=n_0_162
+ VDD=VDD VSS=VSS
Xi_0_189 AOI22_X1 $PINS ZN=n_0_160 A1=n_0_261 A2=n_0_169 B1=n_0_280 B2=n_0_161
+ VDD=VDD VSS=VSS
Xi_0_188 AOI22_X1 $PINS ZN=n_0_159 A1=a[10] A2=n_0_317 B1=a[18] B2=n_0_232
+ VDD=VDD VSS=VSS
Xi_0_187 NOR2_X1 $PINS ZN=n_0_158 A1=n_0_323 A2=n_0_159 VDD=VDD VSS=VSS
Xi_0_186 AOI21_X1 $PINS ZN=n_0_157 A=n_0_158 B1=n_0_323 B2=n_0_217 VDD=VDD
+ VSS=VSS
Xi_0_185 NAND2_X1 $PINS ZN=n_0_156 A1=n_0_309 A2=n_0_185 VDD=VDD VSS=VSS
Xi_0_184 OAI21_X1 $PINS ZN=n_0_155 A=n_0_156 B1=n_0_309 B2=n_0_157 VDD=VDD
+ VSS=VSS
Xi_0_183 AOI22_X1 $PINS ZN=n_0_154 A1=n_0_254 A2=n_0_175 B1=n_0_271 B2=n_0_155
+ VDD=VDD VSS=VSS
Xi_0_182 AOI22_X1 $PINS ZN=n_0_153 A1=n_0_352 A2=n_0_160 B1=n_0_353 B2=n_0_154
+ VDD=VDD VSS=VSS
Xi_0_181 OAI221_X1 $PINS ZN=n_0_152 A=n_0_153 B1=n_0_301 B2=n_0_160 C1=n_0_306
+ C2=n_0_154 VDD=VDD VSS=VSS
Xi_0_180 AOI21_X1 $PINS ZN=n_0_151 A=n_0_152 B1=b[10] B2=n_0_350 VDD=VDD
+ VSS=VSS
Xi_0_179 OAI21_X1 $PINS ZN=n_34 A=n_0_151 B1=b[10] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_178 AOI22_X1 $PINS ZN=n_0_150 A1=b[9] A2=n_0_330 B1=b[17] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_177 AOI22_X1 $PINS ZN=n_0_149 A1=n_0_334 A2=n_0_150 B1=n_0_335 B2=n_0_204
+ VDD=VDD VSS=VSS
Xi_0_176 NOR2_X1 $PINS ZN=n_0_148 A1=n_0_326 A2=n_0_149 VDD=VDD VSS=VSS
Xi_0_175 AOI21_X1 $PINS ZN=n_0_147 A=n_0_148 B1=n_0_326 B2=n_0_171 VDD=VDD
+ VSS=VSS
Xi_0_174 AOI22_X1 $PINS ZN=n_0_146 A1=n_0_261 A2=n_0_161 B1=n_0_280 B2=n_0_147
+ VDD=VDD VSS=VSS
Xi_0_173 AOI22_X1 $PINS ZN=n_0_145 A1=a[9] A2=n_0_317 B1=a[17] B2=n_0_232
+ VDD=VDD VSS=VSS
Xi_0_172 NAND2_X1 $PINS ZN=n_0_144 A1=n_0_322 A2=n_0_145 VDD=VDD VSS=VSS
Xi_0_171 OAI21_X1 $PINS ZN=n_0_143 A=n_0_144 B1=n_0_322 B2=n_0_199 VDD=VDD
+ VSS=VSS
Xi_0_170 AOI22_X1 $PINS ZN=n_0_142 A1=n_0_310 A2=n_0_143 B1=n_0_309 B2=n_0_176
+ VDD=VDD VSS=VSS
Xi_0_169 AOI22_X1 $PINS ZN=n_0_141 A1=n_0_271 A2=n_0_142 B1=n_0_254 B2=n_0_155
+ VDD=VDD VSS=VSS
Xi_0_168 AOI22_X1 $PINS ZN=n_0_140 A1=b[9] A2=n_0_350 B1=n_0_352 B2=n_0_146
+ VDD=VDD VSS=VSS
Xi_0_167 OAI22_X1 $PINS ZN=n_0_139 A1=n_0_301 A2=n_0_146 B1=n_0_306 B2=n_0_141
+ VDD=VDD VSS=VSS
Xi_0_166 AOI21_X1 $PINS ZN=n_0_138 A=n_0_139 B1=n_0_353 B2=n_0_141 VDD=VDD
+ VSS=VSS
Xi_0_165 OAI211_X1 $PINS ZN=n_33 A=n_0_138 B=n_0_140 C1=b[9] C2=n_0_356 VDD=VDD
+ VSS=VSS
Xi_0_164 AOI22_X1 $PINS ZN=n_0_137 A1=b[8] A2=n_0_330 B1=b[16] B2=n_0_226
+ VDD=VDD VSS=VSS
Xi_0_163 NAND2_X1 $PINS ZN=n_0_136 A1=n_0_334 A2=n_0_137 VDD=VDD VSS=VSS
Xi_0_162 OAI21_X1 $PINS ZN=n_0_135 A=n_0_136 B1=n_0_334 B2=n_0_191 VDD=VDD
+ VSS=VSS
Xi_0_161 AOI22_X1 $PINS ZN=n_0_134 A1=n_0_327 A2=n_0_135 B1=n_0_326 B2=n_0_162
+ VDD=VDD VSS=VSS
Xi_0_160 AOI22_X1 $PINS ZN=n_0_133 A1=n_0_261 A2=n_0_147 B1=n_0_280 B2=n_0_134
+ VDD=VDD VSS=VSS
Xi_0_159 AOI22_X1 $PINS ZN=n_0_132 A1=a[8] A2=n_0_317 B1=a[16] B2=n_0_232
+ VDD=VDD VSS=VSS
Xi_0_158 AOI22_X1 $PINS ZN=n_0_131 A1=n_0_322 A2=n_0_132 B1=n_0_323 B2=n_0_186
+ VDD=VDD VSS=VSS
Xi_0_157 INV_X1 $PINS ZN=n_0_130 A=n_0_131 VDD=VDD VSS=VSS
Xi_0_156 AOI22_X1 $PINS ZN=n_0_129 A1=n_0_310 A2=n_0_130 B1=n_0_309 B2=n_0_157
+ VDD=VDD VSS=VSS
Xi_0_155 AOI22_X1 $PINS ZN=n_0_128 A1=n_0_254 A2=n_0_142 B1=n_0_271 B2=n_0_129
+ VDD=VDD VSS=VSS
Xi_0_154 AOI22_X1 $PINS ZN=n_0_127 A1=n_0_352 A2=n_0_133 B1=n_0_353 B2=n_0_128
+ VDD=VDD VSS=VSS
Xi_0_153 OAI221_X1 $PINS ZN=n_0_126 A=n_0_127 B1=n_0_306 B2=n_0_128 C1=n_0_301
+ C2=n_0_133 VDD=VDD VSS=VSS
Xi_0_152 AOI21_X1 $PINS ZN=n_0_125 A=n_0_126 B1=b[8] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_151 OAI21_X1 $PINS ZN=n_32 A=n_0_125 B1=b[8] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_150 NOR2_X1 $PINS ZN=n_0_124 A1=n_0_333 A2=n_0_332 VDD=VDD VSS=VSS
Xi_0_149 AOI222_X1 $PINS ZN=n_0_123 A1=b[15] A2=n_0_226 B1=b[7] B2=n_0_330
+ C1=n_0_402 C2=n_0_124 VDD=VDD VSS=VSS
Xi_0_148 OAI22_X1 $PINS ZN=n_0_122 A1=n_0_334 A2=n_0_173 B1=n_0_335 B2=n_0_123
+ VDD=VDD VSS=VSS
Xi_0_147 INV_X1 $PINS ZN=n_0_121 A=n_0_122 VDD=VDD VSS=VSS
Xi_0_146 NAND2_X1 $PINS ZN=n_0_120 A1=n_0_326 A2=n_0_149 VDD=VDD VSS=VSS
Xi_0_145 OAI21_X1 $PINS ZN=n_0_119 A=n_0_120 B1=n_0_326 B2=n_0_121 VDD=VDD
+ VSS=VSS
Xi_0_144 AOI22_X1 $PINS ZN=n_0_118 A1=n_0_280 A2=n_0_119 B1=n_0_261 B2=n_0_134
+ VDD=VDD VSS=VSS
Xi_0_143 NOR2_X1 $PINS ZN=n_0_117 A1=n_0_321 A2=n_0_319 VDD=VDD VSS=VSS
Xi_0_142 AOI222_X1 $PINS ZN=n_0_116 A1=n_0_404 A2=n_0_117 B1=a[7] B2=n_0_317
+ C1=a[15] C2=n_0_232 VDD=VDD VSS=VSS
Xi_0_141 AOI22_X1 $PINS ZN=n_0_115 A1=n_0_323 A2=n_0_178 B1=n_0_322 B2=n_0_116
+ VDD=VDD VSS=VSS
Xi_0_140 INV_X1 $PINS ZN=n_0_114 A=n_0_115 VDD=VDD VSS=VSS
Xi_0_139 AOI22_X1 $PINS ZN=n_0_113 A1=n_0_310 A2=n_0_114 B1=n_0_309 B2=n_0_143
+ VDD=VDD VSS=VSS
Xi_0_138 AOI22_X1 $PINS ZN=n_0_112 A1=n_0_271 A2=n_0_113 B1=n_0_254 B2=n_0_129
+ VDD=VDD VSS=VSS
Xi_0_137 AOI22_X1 $PINS ZN=n_0_111 A1=n_0_352 A2=n_0_118 B1=n_0_353 B2=n_0_112
+ VDD=VDD VSS=VSS
Xi_0_136 OAI221_X1 $PINS ZN=n_0_110 A=n_0_111 B1=n_0_306 B2=n_0_112 C1=n_0_301
+ C2=n_0_118 VDD=VDD VSS=VSS
Xi_0_135 AOI21_X1 $PINS ZN=n_0_109 A=n_0_110 B1=b[7] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_134 OAI21_X1 $PINS ZN=n_31 A=n_0_109 B1=b[7] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_133 AOI222_X1 $PINS ZN=n_0_108 A1=a[14] A2=n_0_232 B1=a[22] B2=n_0_117
+ C1=a[6] C2=n_0_317 VDD=VDD VSS=VSS
Xi_0_132 AOI22_X1 $PINS ZN=n_0_107 A1=n_0_323 A2=n_0_159 B1=n_0_322 B2=n_0_108
+ VDD=VDD VSS=VSS
Xi_0_131 INV_X1 $PINS ZN=n_0_106 A=n_0_107 VDD=VDD VSS=VSS
Xi_0_130 AOI22_X1 $PINS ZN=n_0_105 A1=n_0_310 A2=n_0_106 B1=n_0_309 B2=n_0_130
+ VDD=VDD VSS=VSS
Xi_0_129 AOI22_X1 $PINS ZN=n_0_104 A1=n_0_254 A2=n_0_113 B1=n_0_271 B2=n_0_105
+ VDD=VDD VSS=VSS
Xi_0_128 AOI222_X1 $PINS ZN=n_0_103 A1=b[14] A2=n_0_226 B1=b[22] B2=n_0_124
+ C1=b[6] C2=n_0_330 VDD=VDD VSS=VSS
Xi_0_127 AOI22_X1 $PINS ZN=n_0_102 A1=n_0_334 A2=n_0_103 B1=n_0_335 B2=n_0_164
+ VDD=VDD VSS=VSS
Xi_0_126 INV_X1 $PINS ZN=n_0_101 A=n_0_102 VDD=VDD VSS=VSS
Xi_0_125 AOI22_X1 $PINS ZN=n_0_100 A1=n_0_326 A2=n_0_135 B1=n_0_327 B2=n_0_101
+ VDD=VDD VSS=VSS
Xi_0_124 AOI22_X1 $PINS ZN=n_0_99 A1=n_0_261 A2=n_0_119 B1=n_0_280 B2=n_0_100
+ VDD=VDD VSS=VSS
Xi_0_123 AOI22_X1 $PINS ZN=n_0_98 A1=n_0_353 A2=n_0_104 B1=n_0_352 B2=n_0_99
+ VDD=VDD VSS=VSS
Xi_0_122 OAI221_X1 $PINS ZN=n_0_97 A=n_0_98 B1=n_0_301 B2=n_0_99 C1=n_0_306
+ C2=n_0_104 VDD=VDD VSS=VSS
Xi_0_121 AOI21_X1 $PINS ZN=n_0_96 A=n_0_97 B1=b[6] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_120 OAI21_X1 $PINS ZN=n_30 A=n_0_96 B1=b[6] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_119 AOI222_X1 $PINS ZN=n_0_95 A1=a[13] A2=n_0_232 B1=a[21] B2=n_0_117
+ C1=a[5] C2=n_0_317 VDD=VDD VSS=VSS
Xi_0_118 AOI22_X1 $PINS ZN=n_0_94 A1=n_0_322 A2=n_0_95 B1=n_0_323 B2=n_0_145
+ VDD=VDD VSS=VSS
Xi_0_117 INV_X1 $PINS ZN=n_0_93 A=n_0_94 VDD=VDD VSS=VSS
Xi_0_116 AOI22_X1 $PINS ZN=n_0_92 A1=n_0_310 A2=n_0_93 B1=n_0_309 B2=n_0_114
+ VDD=VDD VSS=VSS
Xi_0_115 AOI22_X1 $PINS ZN=n_0_91 A1=n_0_254 A2=n_0_105 B1=n_0_271 B2=n_0_92
+ VDD=VDD VSS=VSS
Xi_0_114 AOI222_X1 $PINS ZN=n_0_90 A1=b[13] A2=n_0_226 B1=b[21] B2=n_0_124
+ C1=b[5] C2=n_0_330 VDD=VDD VSS=VSS
Xi_0_113 INV_X1 $PINS ZN=n_0_89 A=n_0_90 VDD=VDD VSS=VSS
Xi_0_112 NAND2_X1 $PINS ZN=n_0_88 A1=n_0_335 A2=n_0_150 VDD=VDD VSS=VSS
Xi_0_111 OAI21_X1 $PINS ZN=n_0_87 A=n_0_88 B1=n_0_335 B2=n_0_89 VDD=VDD VSS=VSS
Xi_0_110 AOI22_X1 $PINS ZN=n_0_86 A1=n_0_327 A2=n_0_87 B1=n_0_326 B2=n_0_121
+ VDD=VDD VSS=VSS
Xi_0_109 AOI22_X1 $PINS ZN=n_0_85 A1=n_0_261 A2=n_0_100 B1=n_0_280 B2=n_0_86
+ VDD=VDD VSS=VSS
Xi_0_108 AOI22_X1 $PINS ZN=n_0_84 A1=n_0_353 A2=n_0_91 B1=n_0_352 B2=n_0_85
+ VDD=VDD VSS=VSS
Xi_0_107 OAI221_X1 $PINS ZN=n_0_83 A=n_0_84 B1=n_0_306 B2=n_0_91 C1=n_0_301
+ C2=n_0_85 VDD=VDD VSS=VSS
Xi_0_106 AOI21_X1 $PINS ZN=n_0_82 A=n_0_83 B1=b[5] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_105 OAI21_X1 $PINS ZN=n_29 A=n_0_82 B1=b[5] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_104 AOI222_X1 $PINS ZN=n_0_81 A1=a[12] A2=n_0_232 B1=a[20] B2=n_0_117
+ C1=a[4] C2=n_0_317 VDD=VDD VSS=VSS
Xi_0_103 AOI22_X1 $PINS ZN=n_0_80 A1=n_0_323 A2=n_0_132 B1=n_0_322 B2=n_0_81
+ VDD=VDD VSS=VSS
Xi_0_102 INV_X1 $PINS ZN=n_0_79 A=n_0_80 VDD=VDD VSS=VSS
Xi_0_101 AOI22_X1 $PINS ZN=n_0_78 A1=n_0_310 A2=n_0_79 B1=n_0_309 B2=n_0_106
+ VDD=VDD VSS=VSS
Xi_0_100 AOI22_X1 $PINS ZN=n_0_77 A1=n_0_254 A2=n_0_92 B1=n_0_271 B2=n_0_78
+ VDD=VDD VSS=VSS
Xi_0_99 INV_X1 $PINS ZN=n_0_76 A=n_0_77 VDD=VDD VSS=VSS
Xi_0_98 AOI222_X1 $PINS ZN=n_0_75 A1=b[12] A2=n_0_226 B1=b[20] B2=n_0_124
+ C1=b[4] C2=n_0_330 VDD=VDD VSS=VSS
Xi_0_97 AOI22_X1 $PINS ZN=n_0_74 A1=n_0_334 A2=n_0_75 B1=n_0_335 B2=n_0_137
+ VDD=VDD VSS=VSS
Xi_0_96 NOR2_X1 $PINS ZN=n_0_73 A1=n_0_326 A2=n_0_74 VDD=VDD VSS=VSS
Xi_0_95 AOI21_X1 $PINS ZN=n_0_72 A=n_0_73 B1=n_0_326 B2=n_0_101 VDD=VDD VSS=VSS
Xi_0_94 AOI22_X1 $PINS ZN=n_0_71 A1=n_0_261 A2=n_0_86 B1=n_0_280 B2=n_0_72
+ VDD=VDD VSS=VSS
Xi_0_93 AOI22_X1 $PINS ZN=n_0_70 A1=b[4] A2=n_0_350 B1=n_0_352 B2=n_0_71
+ VDD=VDD VSS=VSS
Xi_0_92 OAI221_X1 $PINS ZN=n_0_69 A=n_0_70 B1=n_0_301 B2=n_0_71 C1=b[4]
+ C2=n_0_356 VDD=VDD VSS=VSS
Xi_0_91 AOI21_X1 $PINS ZN=n_0_68 A=n_0_69 B1=n_0_305 B2=n_0_76 VDD=VDD VSS=VSS
Xi_0_90 OAI21_X1 $PINS ZN=n_28 A=n_0_68 B1=n_0_354 B2=n_0_76 VDD=VDD VSS=VSS
Xi_0_89 AOI222_X1 $PINS ZN=n_0_67 A1=b[11] A2=n_0_226 B1=b[3] B2=n_0_330
+ C1=b[19] C2=n_0_124 VDD=VDD VSS=VSS
Xi_0_88 AOI22_X1 $PINS ZN=n_0_66 A1=n_0_335 A2=n_0_123 B1=n_0_334 B2=n_0_67
+ VDD=VDD VSS=VSS
Xi_0_87 INV_X1 $PINS ZN=n_0_65 A=n_0_66 VDD=VDD VSS=VSS
Xi_0_86 AOI22_X1 $PINS ZN=n_0_64 A1=n_0_327 A2=n_0_65 B1=n_0_326 B2=n_0_87
+ VDD=VDD VSS=VSS
Xi_0_85 AOI22_X1 $PINS ZN=n_0_63 A1=n_0_261 A2=n_0_72 B1=n_0_280 B2=n_0_64
+ VDD=VDD VSS=VSS
Xi_0_84 AOI222_X1 $PINS ZN=n_0_62 A1=a[11] A2=n_0_232 B1=a[19] B2=n_0_117
+ C1=a[3] C2=n_0_317 VDD=VDD VSS=VSS
Xi_0_83 AOI22_X1 $PINS ZN=n_0_61 A1=n_0_323 A2=n_0_116 B1=n_0_322 B2=n_0_62
+ VDD=VDD VSS=VSS
Xi_0_82 NOR2_X1 $PINS ZN=n_0_60 A1=n_0_309 A2=n_0_61 VDD=VDD VSS=VSS
Xi_0_81 AOI21_X1 $PINS ZN=n_0_59 A=n_0_60 B1=n_0_309 B2=n_0_93 VDD=VDD VSS=VSS
Xi_0_80 AOI22_X1 $PINS ZN=n_0_58 A1=n_0_254 A2=n_0_78 B1=n_0_271 B2=n_0_59
+ VDD=VDD VSS=VSS
Xi_0_79 AOI22_X1 $PINS ZN=n_0_57 A1=n_0_352 A2=n_0_63 B1=n_0_353 B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_78 OAI221_X1 $PINS ZN=n_0_56 A=n_0_57 B1=n_0_301 B2=n_0_63 C1=n_0_306
+ C2=n_0_58 VDD=VDD VSS=VSS
Xi_0_77 AOI21_X1 $PINS ZN=n_0_55 A=n_0_56 B1=b[3] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_76 OAI21_X1 $PINS ZN=n_27 A=n_0_55 B1=b[3] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_75 AOI222_X1 $PINS ZN=n_0_54 A1=a[10] A2=n_0_232 B1=a[18] B2=n_0_117
+ C1=a[2] C2=n_0_317 VDD=VDD VSS=VSS
Xi_0_74 AOI22_X1 $PINS ZN=n_0_53 A1=n_0_323 A2=n_0_108 B1=n_0_322 B2=n_0_54
+ VDD=VDD VSS=VSS
Xi_0_73 INV_X1 $PINS ZN=n_0_52 A=n_0_53 VDD=VDD VSS=VSS
Xi_0_72 AOI22_X1 $PINS ZN=n_0_51 A1=n_0_310 A2=n_0_52 B1=n_0_309 B2=n_0_79
+ VDD=VDD VSS=VSS
Xi_0_71 AOI22_X1 $PINS ZN=n_0_50 A1=n_0_254 A2=n_0_59 B1=n_0_271 B2=n_0_51
+ VDD=VDD VSS=VSS
Xi_0_70 AOI222_X1 $PINS ZN=n_0_49 A1=b[18] A2=n_0_124 B1=b[2] B2=n_0_330
+ C1=b[10] C2=n_0_226 VDD=VDD VSS=VSS
Xi_0_69 AOI22_X1 $PINS ZN=n_0_48 A1=n_0_334 A2=n_0_49 B1=n_0_335 B2=n_0_103
+ VDD=VDD VSS=VSS
Xi_0_68 INV_X1 $PINS ZN=n_0_47 A=n_0_48 VDD=VDD VSS=VSS
Xi_0_67 NAND2_X1 $PINS ZN=n_0_46 A1=n_0_326 A2=n_0_74 VDD=VDD VSS=VSS
Xi_0_66 OAI21_X1 $PINS ZN=n_0_45 A=n_0_46 B1=n_0_326 B2=n_0_47 VDD=VDD VSS=VSS
Xi_0_65 AOI22_X1 $PINS ZN=n_0_44 A1=n_0_280 A2=n_0_45 B1=n_0_261 B2=n_0_64
+ VDD=VDD VSS=VSS
Xi_0_64 AOI22_X1 $PINS ZN=n_0_43 A1=n_0_352 A2=n_0_44 B1=n_0_353 B2=n_0_50
+ VDD=VDD VSS=VSS
Xi_0_63 OAI221_X1 $PINS ZN=n_0_42 A=n_0_43 B1=n_0_306 B2=n_0_50 C1=n_0_301
+ C2=n_0_44 VDD=VDD VSS=VSS
Xi_0_62 AOI21_X1 $PINS ZN=n_0_41 A=n_0_42 B1=b[2] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_61 OAI21_X1 $PINS ZN=n_26 A=n_0_41 B1=b[2] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_60 AOI222_X1 $PINS ZN=n_0_40 A1=b[1] A2=n_0_330 B1=b[17] B2=n_0_124
+ C1=b[9] C2=n_0_226 VDD=VDD VSS=VSS
Xi_0_59 INV_X1 $PINS ZN=n_0_39 A=n_0_40 VDD=VDD VSS=VSS
Xi_0_58 AOI221_X1 $PINS ZN=n_0_38 A=n_0_326 B1=n_0_334 B2=n_0_39 C1=n_0_335
+ C2=n_0_89 VDD=VDD VSS=VSS
Xi_0_57 AOI21_X1 $PINS ZN=n_0_37 A=n_0_38 B1=n_0_326 B2=n_0_65 VDD=VDD VSS=VSS
Xi_0_56 AOI22_X1 $PINS ZN=n_0_36 A1=n_0_261 A2=n_0_45 B1=n_0_280 B2=n_0_37
+ VDD=VDD VSS=VSS
Xi_0_55 AOI222_X1 $PINS ZN=n_0_35 A1=a[1] A2=n_0_317 B1=a[17] B2=n_0_117
+ C1=a[9] C2=n_0_232 VDD=VDD VSS=VSS
Xi_0_54 AOI221_X1 $PINS ZN=n_0_34 A=n_0_309 B1=n_0_322 B2=n_0_35 C1=n_0_323
+ C2=n_0_95 VDD=VDD VSS=VSS
Xi_0_53 AOI21_X1 $PINS ZN=n_0_33 A=n_0_34 B1=n_0_309 B2=n_0_61 VDD=VDD VSS=VSS
Xi_0_52 INV_X1 $PINS ZN=n_0_32 A=n_0_33 VDD=VDD VSS=VSS
Xi_0_51 AOI22_X1 $PINS ZN=n_0_31 A1=n_0_271 A2=n_0_32 B1=n_0_254 B2=n_0_51
+ VDD=VDD VSS=VSS
Xi_0_50 OAI22_X1 $PINS ZN=n_0_30 A1=n_0_301 A2=n_0_36 B1=n_0_306 B2=n_0_31
+ VDD=VDD VSS=VSS
Xi_0_49 AOI21_X1 $PINS ZN=n_0_29 A=n_0_30 B1=n_0_352 B2=n_0_36 VDD=VDD VSS=VSS
Xi_0_48 AOI22_X1 $PINS ZN=n_0_28 A1=b[1] A2=n_0_350 B1=n_0_353 B2=n_0_31
+ VDD=VDD VSS=VSS
Xi_0_47 OAI211_X1 $PINS ZN=n_25 A=n_0_29 B=n_0_28 C1=b[1] C2=n_0_356 VDD=VDD
+ VSS=VSS
Xi_0_46 AOI222_X1 $PINS ZN=n_0_27 A1=b[8] A2=n_0_226 B1=b[16] B2=n_0_124
+ C1=b[0] C2=n_0_330 VDD=VDD VSS=VSS
Xi_0_45 OAI221_X1 $PINS ZN=n_0_26 A=n_0_327 B1=n_0_335 B2=n_0_27 C1=n_0_334
+ C2=n_0_75 VDD=VDD VSS=VSS
Xi_0_44 AOI21_X1 $PINS ZN=n_0_25 A=n_0_281 B1=n_0_326 B2=n_0_47 VDD=VDD VSS=VSS
Xi_0_43 AOI22_X1 $PINS ZN=n_0_24 A1=n_0_261 A2=n_0_37 B1=n_0_26 B2=n_0_25
+ VDD=VDD VSS=VSS
Xi_0_42 AOI222_X1 $PINS ZN=n_0_23 A1=a[16] A2=n_0_117 B1=a[0] B2=n_0_317
+ C1=a[8] C2=n_0_232 VDD=VDD VSS=VSS
Xi_0_41 OAI221_X1 $PINS ZN=n_0_22 A=n_0_310 B1=n_0_323 B2=n_0_23 C1=n_0_322
+ C2=n_0_81 VDD=VDD VSS=VSS
Xi_0_40 AOI21_X1 $PINS ZN=n_0_21 A=n_0_272 B1=n_0_309 B2=n_0_52 VDD=VDD VSS=VSS
Xi_0_39 AOI22_X1 $PINS ZN=n_0_20 A1=n_0_254 A2=n_0_32 B1=n_0_22 B2=n_0_21
+ VDD=VDD VSS=VSS
Xi_0_38 AOI22_X1 $PINS ZN=n_0_19 A1=n_0_352 A2=n_0_24 B1=n_0_353 B2=n_0_20
+ VDD=VDD VSS=VSS
Xi_0_37 OAI221_X1 $PINS ZN=n_0_18 A=n_0_19 B1=n_0_301 B2=n_0_24 C1=n_0_306
+ C2=n_0_20 VDD=VDD VSS=VSS
Xi_0_36 AOI21_X1 $PINS ZN=n_0_17 A=n_0_18 B1=b[0] B2=n_0_350 VDD=VDD VSS=VSS
Xi_0_35 OAI21_X1 $PINS ZN=n_24 A=n_0_17 B1=b[0] B2=n_0_356 VDD=VDD VSS=VSS
Xi_0_34 OAI221_X1 $PINS ZN=n_23 A=n_0_438 B1=n_0_404 B2=n_0_397 C1=n_0_405
+ C2=n_0_396 VDD=VDD VSS=VSS
Xi_0_33 OAI222_X1 $PINS ZN=n_22 A1=n_0_528 A2=n_0_438 B1=a[22] B2=n_0_397
+ C1=n_0_498 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_32 OAI222_X1 $PINS ZN=n_21 A1=n_0_527 A2=n_0_438 B1=a[21] B2=n_0_397
+ C1=n_0_497 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_31 OAI222_X1 $PINS ZN=n_20 A1=n_0_526 A2=n_0_438 B1=a[20] B2=n_0_397
+ C1=n_0_496 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_30 OAI222_X1 $PINS ZN=n_19 A1=n_0_525 A2=n_0_438 B1=a[19] B2=n_0_397
+ C1=n_0_495 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_29 OAI222_X1 $PINS ZN=n_18 A1=n_0_524 A2=n_0_438 B1=a[18] B2=n_0_397
+ C1=n_0_494 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_28 OAI222_X1 $PINS ZN=n_17 A1=n_0_523 A2=n_0_438 B1=a[17] B2=n_0_397
+ C1=n_0_493 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_27 AOI22_X1 $PINS ZN=n_0_16 A1=b[16] A2=n_0_437 B1=n_0_492 B2=n_0_396
+ VDD=VDD VSS=VSS
Xi_0_26 OAI21_X1 $PINS ZN=n_16 A=n_0_16 B1=n_0_492 B2=n_0_395 VDD=VDD VSS=VSS
Xi_0_25 OAI222_X1 $PINS ZN=n_15 A1=n_0_522 A2=n_0_438 B1=a[15] B2=n_0_397
+ C1=n_0_491 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_24 OAI222_X1 $PINS ZN=n_14 A1=n_0_521 A2=n_0_438 B1=a[14] B2=n_0_397
+ C1=n_0_490 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_23 OAI222_X1 $PINS ZN=n_13 A1=n_0_520 A2=n_0_438 B1=a[13] B2=n_0_397
+ C1=n_0_489 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_22 OAI222_X1 $PINS ZN=n_12 A1=n_0_519 A2=n_0_438 B1=a[12] B2=n_0_397
+ C1=n_0_488 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_21 OAI222_X1 $PINS ZN=n_11 A1=n_0_518 A2=n_0_438 B1=a[11] B2=n_0_397
+ C1=n_0_487 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_20 OAI222_X1 $PINS ZN=n_10 A1=n_0_517 A2=n_0_438 B1=a[10] B2=n_0_397
+ C1=n_0_486 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_19 OAI222_X1 $PINS ZN=n_9 A1=n_0_516 A2=n_0_438 B1=a[9] B2=n_0_397
+ C1=n_0_485 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_18 OAI222_X1 $PINS ZN=n_8 A1=n_0_515 A2=n_0_438 B1=a[8] B2=n_0_397
+ C1=n_0_484 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_17 OAI222_X1 $PINS ZN=n_7 A1=n_0_514 A2=n_0_438 B1=a[7] B2=n_0_397
+ C1=n_0_483 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_16 OAI222_X1 $PINS ZN=n_6 A1=n_0_513 A2=n_0_438 B1=a[6] B2=n_0_397
+ C1=n_0_482 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_15 AOI22_X1 $PINS ZN=n_0_15 A1=a[5] A2=n_0_394 B1=b[5] B2=n_0_437 VDD=VDD
+ VSS=VSS
Xi_0_14 OAI21_X1 $PINS ZN=n_5 A=n_0_15 B1=a[5] B2=n_0_397 VDD=VDD VSS=VSS
Xi_0_13 OAI222_X1 $PINS ZN=n_4 A1=n_0_511 A2=n_0_438 B1=a[4] B2=n_0_397
+ C1=n_0_481 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_12 AOI22_X1 $PINS ZN=n_0_14 A1=a[3] A2=n_0_394 B1=b[3] B2=n_0_437 VDD=VDD
+ VSS=VSS
Xi_0_11 OAI21_X1 $PINS ZN=n_3 A=n_0_14 B1=a[3] B2=n_0_397 VDD=VDD VSS=VSS
Xi_0_10 OAI222_X1 $PINS ZN=n_2 A1=n_0_509 A2=n_0_438 B1=a[2] B2=n_0_397
+ C1=n_0_480 C2=n_0_395 VDD=VDD VSS=VSS
Xi_0_9 AOI22_X1 $PINS ZN=n_0_13 A1=a[1] A2=n_0_394 B1=b[1] B2=n_0_437 VDD=VDD
+ VSS=VSS
Xi_0_8 OAI21_X1 $PINS ZN=n_1 A=n_0_13 B1=a[1] B2=n_0_397 VDD=VDD VSS=VSS
Xi_0_7 AOI22_X1 $PINS ZN=n_0_12 A1=a[0] A2=n_0_394 B1=b[0] B2=n_0_437 VDD=VDD
+ VSS=VSS
Xi_0_6 OAI21_X1 $PINS ZN=n_0 A=n_0_12 B1=a[0] B2=n_0_397 VDD=VDD VSS=VSS
Xi_0_5 HA_X1 $PINS CO=n_0_5 S=n_0_11 A=n_55 B=n_0_4 VDD=VDD VSS=VSS
Xi_0_4 HA_X1 $PINS CO=n_0_4 S=n_0_10 A=n_54 B=n_0_3 VDD=VDD VSS=VSS
Xi_0_3 HA_X1 $PINS CO=n_0_3 S=n_0_9 A=n_53 B=n_0_2 VDD=VDD VSS=VSS
Xi_0_2 HA_X1 $PINS CO=n_0_2 S=n_0_8 A=n_52 B=n_0_1 VDD=VDD VSS=VSS
Xi_0_1 HA_X1 $PINS CO=n_0_1 S=n_0_7 A=n_51 B=n_0_0 VDD=VDD VSS=VSS
Xi_0_0 HA_X1 $PINS CO=n_0_0 S=n_0_6 A=n_50 B=n_49 VDD=VDD VSS=VSS
Xi_e_reg[0] DLH_X1 $PINS Q=i_e[0] D=n_49 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[1] DLH_X1 $PINS Q=i_e[1] D=n_50 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[2] DLH_X1 $PINS Q=i_e[2] D=n_51 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[3] DLH_X1 $PINS Q=i_e[3] D=n_52 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[4] DLH_X1 $PINS Q=i_e[4] D=n_53 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[5] DLH_X1 $PINS Q=i_e[5] D=n_54 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[6] DLH_X1 $PINS Q=i_e[6] D=n_55 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_e_reg[7] DLH_X1 $PINS Q=i_e[7] D=n_56 G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[0] DLH_X1 $PINS Q=i_m[0] D=CLA_SUM[0] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[1] DLH_X1 $PINS Q=i_m[1] D=CLA_SUM[1] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[2] DLH_X1 $PINS Q=i_m[2] D=CLA_SUM[2] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[3] DLH_X1 $PINS Q=i_m[3] D=CLA_SUM[3] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[4] DLH_X1 $PINS Q=i_m[4] D=CLA_SUM[4] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[5] DLH_X1 $PINS Q=i_m[5] D=CLA_SUM[5] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[6] DLH_X1 $PINS Q=i_m[6] D=CLA_SUM[6] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[7] DLH_X1 $PINS Q=i_m[7] D=CLA_SUM[7] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[8] DLH_X1 $PINS Q=i_m[8] D=CLA_SUM[8] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[9] DLH_X1 $PINS Q=i_m[9] D=CLA_SUM[9] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[10] DLH_X1 $PINS Q=i_m[10] D=CLA_SUM[10] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[11] DLH_X1 $PINS Q=i_m[11] D=CLA_SUM[11] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[12] DLH_X1 $PINS Q=i_m[12] D=CLA_SUM[12] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[13] DLH_X1 $PINS Q=i_m[13] D=CLA_SUM[13] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[14] DLH_X1 $PINS Q=i_m[14] D=CLA_SUM[14] G=hfn_ipo_n6 VDD=VDD VSS=VSS
Xi_m_reg[15] DLH_X1 $PINS Q=i_m[15] D=CLA_SUM[15] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[16] DLH_X1 $PINS Q=i_m[16] D=CLA_SUM[16] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[17] DLH_X1 $PINS Q=i_m[17] D=CLA_SUM[17] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[18] DLH_X1 $PINS Q=i_m[18] D=CLA_SUM[18] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[19] DLH_X1 $PINS Q=i_m[19] D=CLA_SUM[19] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[20] DLH_X1 $PINS Q=i_m[20] D=CLA_SUM[20] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[21] DLH_X1 $PINS Q=i_m[21] D=CLA_SUM[21] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[22] DLH_X1 $PINS Q=i_m[22] D=CLA_SUM[22] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xi_m_reg[23] DLH_X1 $PINS Q=i_m[23] D=CLA_SUM[23] G=hfn_ipo_n5 VDD=VDD VSS=VSS
Xc1 CLA_adder $PINS Cout=CLA_COUT Overflow=of Sum[23]=CLA_SUM[23]
+ Sum[22]=CLA_SUM[22] Sum[21]=CLA_SUM[21] Sum[20]=CLA_SUM[20] Sum[19]=CLA_SUM[19]
+ Sum[18]=CLA_SUM[18] Sum[17]=CLA_SUM[17] Sum[16]=CLA_SUM[16] Sum[15]=CLA_SUM[15]
+ Sum[14]=CLA_SUM[14] Sum[13]=CLA_SUM[13] Sum[12]=CLA_SUM[12] Sum[11]=CLA_SUM[11]
+ Sum[10]=CLA_SUM[10] Sum[9]=CLA_SUM[9] Sum[8]=CLA_SUM[8] Sum[7]=CLA_SUM[7]
+ Sum[6]=CLA_SUM[6] Sum[5]=CLA_SUM[5] Sum[4]=CLA_SUM[4] Sum[3]=CLA_SUM[3]
+ Sum[2]=CLA_SUM[2] Sum[1]=CLA_SUM[1] Sum[0]=CLA_SUM[0] A[23]=n_23 A[22]=n_22
+ A[21]=n_21 A[20]=n_20 A[19]=n_19 A[18]=n_18 A[17]=n_17 A[16]=n_16 A[15]=n_15
+ A[14]=n_14 A[13]=n_13 A[12]=n_12 A[11]=n_11 A[10]=n_10 A[9]=n_9 A[8]=n_8
+ A[7]=n_7 A[6]=n_6 A[5]=n_5 A[4]=n_4 A[3]=n_3 A[2]=n_2 A[1]=n_1 A[0]=n_0
+ B[23]=n_47 B[22]=n_46 B[21]=n_45 B[20]=n_44 B[19]=n_43 B[18]=n_42 B[17]=n_41
+ B[16]=n_40 B[15]=n_39 B[14]=n_38 B[13]=n_37 B[12]=n_36 B[11]=n_35 B[10]=n_34
+ B[9]=n_33 B[8]=n_32 B[7]=n_31 B[6]=n_30 B[5]=n_29 B[4]=n_28 B[3]=n_27 B[2]=n_26
+ B[1]=n_25 B[0]=n_24 VDD=VDD VSS=VSS
Xnorm1 addition_normaliser $PINS out_e[7]=o_e[7] out_e[6]=o_e[6]
+ out_e[5]=o_e[5] out_e[4]=o_e[4] out_e[3]=o_e[3] out_e[2]=o_e[2] out_e[1]=o_e[1]
+ out_e[0]=o_e[0] out_m[24]=uc_1 out_m[23]=uc_2 out_m[22]=o_m[22]
+ out_m[21]=o_m[21] out_m[20]=o_m[20] out_m[19]=o_m[19] out_m[18]=o_m[18]
+ out_m[17]=o_m[17] out_m[16]=o_m[16] out_m[15]=o_m[15] out_m[14]=o_m[14]
+ out_m[13]=o_m[13] out_m[12]=o_m[12] out_m[11]=o_m[11] out_m[10]=o_m[10]
+ out_m[9]=o_m[9] out_m[8]=o_m[8] out_m[7]=o_m[7] out_m[6]=o_m[6] out_m[5]=o_m[5]
+ out_m[4]=o_m[4] out_m[3]=o_m[3] out_m[2]=o_m[2] out_m[1]=o_m[1] out_m[0]=uc_3
+ in_e[7]=i_e[7] in_e[6]=i_e[6] in_e[5]=i_e[5] in_e[4]=i_e[4] in_e[3]=i_e[3]
+ in_e[2]=i_e[2] in_e[1]=i_e[1] in_e[0]=i_e[0] in_m[24]=uc_0 in_m[23]=i_m[23]
+ in_m[22]=i_m[22] in_m[21]=i_m[21] in_m[20]=i_m[20] in_m[19]=i_m[19]
+ in_m[18]=i_m[18] in_m[17]=i_m[17] in_m[16]=i_m[16] in_m[15]=i_m[15]
+ in_m[14]=i_m[14] in_m[13]=i_m[13] in_m[12]=i_m[12] in_m[11]=i_m[11]
+ in_m[10]=i_m[10] in_m[9]=i_m[9] in_m[8]=i_m[8] in_m[7]=i_m[7] in_m[6]=i_m[6]
+ in_m[5]=i_m[5] in_m[4]=i_m[4] in_m[3]=i_m[3] in_m[2]=i_m[2] in_m[1]=i_m[1]
+ in_m[0]=i_m[0] VDD=VDD VSS=VSS
Xhfn_ipo_c5 CLKBUF_X1 $PINS Z=hfn_ipo_n5 A=n_48 VDD=VDD VSS=VSS
Xhfn_ipo_c6 CLKBUF_X1 $PINS Z=hfn_ipo_n6 A=n_48 VDD=VDD VSS=VSS
.ENDS

.SUBCKT fpa VDD VSS A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23] A[22]
+ A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10] A[9]
+ A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28] B[27]
+ B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15] B[14]
+ B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1] B[0]
+ O[31] O[30] O[29] O[28] O[27] O[26] O[25] O[24] O[23] O[22] O[21] O[20] O[19]
+ O[18] O[17] O[16] O[15] O[14] O[13] O[12] O[11] O[10] O[9] O[8] O[7] O[6]
+ O[5] O[4] O[3] O[2] O[1] O[0] OF
Xi_0_106 INV_X1 $PINS ZN=n_0_73 A=hfn_ipo_n9 VDD=VDD VSS=VSS
Xi_0_97 OAI221_X1 $PINS ZN=O[0] A=n_0_61 B1=n_0_59 B2=n_0_62 C1=n_0_58
+ C2=n_0_63 VDD=VDD VSS=VSS
Xi_0_96 INV_X1 $PINS ZN=n_0_63 A=A[0] VDD=VDD VSS=VSS
Xi_0_95 INV_X1 $PINS ZN=n_0_62 A=B[0] VDD=VDD VSS=VSS
Xi_0_94 NAND2_X1 $PINS ZN=n_0_61 A1=hfn_ipo_n10 A2=adder_out[0] VDD=VDD VSS=VSS
Xi_0_93 INV_X2 $PINS ZN=n_0_60 A=n_0_59 VDD=VDD VSS=VSS
Xi_0_92 NAND2_X1 $PINS ZN=n_0_59 A1=n_0_58 A2=n_0_57 VDD=VDD VSS=VSS
Xi_0_91 INV_X1 $PINS ZN=n_0_58 A=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_90 NOR2_X1 $PINS ZN=n_0 A1=drc_ipo_n11 A2=n_0_57 VDD=VDD VSS=VSS
Xi_0_89 OAI22_X1 $PINS ZN=n_0_57 A1=n_0_49 A2=n_0_54 B1=n_0_55 B2=n_0_56
+ VDD=VDD VSS=VSS
Xi_0_88 NAND4_X1 $PINS ZN=n_0_56 A1=B[30] A2=B[29] A3=B[28] A4=B[27] VDD=VDD
+ VSS=VSS
Xi_0_87 NAND4_X1 $PINS ZN=n_0_55 A1=B[26] A2=B[25] A3=B[24] A4=B[23] VDD=VDD
+ VSS=VSS
Xi_0_86 NAND4_X1 $PINS ZN=n_0_54 A1=n_0_50 A2=n_0_51 A3=n_0_52 A4=n_0_53
+ VDD=VDD VSS=VSS
Xi_0_85 NOR3_X1 $PINS ZN=n_0_53 A1=A[2] A2=A[1] A3=A[0] VDD=VDD VSS=VSS
Xi_0_84 NOR4_X1 $PINS ZN=n_0_52 A1=A[6] A2=A[5] A3=A[4] A4=A[3] VDD=VDD VSS=VSS
Xi_0_83 NOR4_X1 $PINS ZN=n_0_51 A1=A[10] A2=A[7] A3=A[9] A4=A[8] VDD=VDD
+ VSS=VSS
Xi_0_82 NOR4_X1 $PINS ZN=n_0_50 A1=A[14] A2=A[13] A3=A[12] A4=A[11] VDD=VDD
+ VSS=VSS
Xi_0_81 NAND4_X1 $PINS ZN=n_0_49 A1=n_0_45 A2=n_0_46 A3=n_0_47 A4=n_0_48
+ VDD=VDD VSS=VSS
Xi_0_80 NOR4_X1 $PINS ZN=n_0_48 A1=A[22] A2=A[21] A3=A[20] A4=A[19] VDD=VDD
+ VSS=VSS
Xi_0_79 NOR4_X1 $PINS ZN=n_0_47 A1=A[18] A2=A[17] A3=A[16] A4=A[15] VDD=VDD
+ VSS=VSS
Xi_0_78 NOR4_X1 $PINS ZN=n_0_46 A1=A[26] A2=A[25] A3=A[24] A4=A[23] VDD=VDD
+ VSS=VSS
Xi_0_77 NOR4_X1 $PINS ZN=n_0_45 A1=A[30] A2=A[29] A3=A[28] A4=A[27] VDD=VDD
+ VSS=VSS
Xi_0_76 OAI33_X1 $PINS ZN=n_0_44 A1=n_0_35 A2=n_0_36 A3=n_0_40 B1=n_0_41
+ B2=n_0_42 B3=n_0_43 VDD=VDD VSS=VSS
Xi_0_75 NAND4_X1 $PINS ZN=n_0_43 A1=A[26] A2=A[25] A3=A[24] A4=A[23] VDD=VDD
+ VSS=VSS
Xi_0_74 NAND3_X1 $PINS ZN=n_0_42 A1=A[30] A2=A[29] A3=A[28] VDD=VDD VSS=VSS
Xi_0_73 INV_X1 $PINS ZN=n_0_41 A=A[27] VDD=VDD VSS=VSS
Xi_0_72 NAND3_X1 $PINS ZN=n_0_40 A1=n_0_37 A2=n_0_38 A3=n_0_39 VDD=VDD VSS=VSS
Xi_0_71 NOR4_X1 $PINS ZN=n_0_39 A1=B[22] A2=B[21] A3=B[20] A4=B[19] VDD=VDD
+ VSS=VSS
Xi_0_70 NOR4_X1 $PINS ZN=n_0_38 A1=B[26] A2=B[25] A3=B[24] A4=B[23] VDD=VDD
+ VSS=VSS
Xi_0_69 NOR4_X2 $PINS ZN=n_0_37 A1=B[10] A2=B[9] A3=B[8] A4=B[7] VDD=VDD
+ VSS=VSS
Xi_0_68 OR4_X1 $PINS ZN=n_0_36 A1=B[6] A2=B[3] A3=B[2] A4=B[0] VDD=VDD VSS=VSS
Xi_0_67 NAND3_X1 $PINS ZN=n_0_35 A1=n_0_32 A2=n_0_33 A3=n_0_34 VDD=VDD VSS=VSS
Xi_0_66 NOR4_X2 $PINS ZN=n_0_34 A1=B[18] A2=B[17] A3=B[16] A4=B[15] VDD=VDD
+ VSS=VSS
Xi_0_65 NOR4_X2 $PINS ZN=n_0_33 A1=B[30] A2=B[29] A3=B[28] A4=B[27] VDD=VDD
+ VSS=VSS
Xi_0_64 NOR4_X1 $PINS ZN=n_0_32 A1=n_0_0 A2=B[1] A3=B[4] A4=B[5] VDD=VDD
+ VSS=VSS
Xi_0_47 OR4_X1 $PINS ZN=n_0_0 A1=B[14] A2=B[13] A3=B[12] A4=B[11] VDD=VDD
+ VSS=VSS
Xi_0_105 INV_X1 $PINS ZN=n_0_72 A=B[31] VDD=VDD VSS=VSS
Xi_0_104 INV_X1 $PINS ZN=n_0_71 A=B[30] VDD=VDD VSS=VSS
Xi_0_103 INV_X1 $PINS ZN=n_0_70 A=B[29] VDD=VDD VSS=VSS
Xi_0_102 INV_X1 $PINS ZN=n_0_69 A=B[28] VDD=VDD VSS=VSS
Xi_0_101 INV_X1 $PINS ZN=n_0_68 A=B[27] VDD=VDD VSS=VSS
Xi_0_100 INV_X1 $PINS ZN=n_0_67 A=B[26] VDD=VDD VSS=VSS
Xi_0_99 INV_X1 $PINS ZN=n_0_66 A=B[25] VDD=VDD VSS=VSS
Xi_0_98 INV_X1 $PINS ZN=n_0_65 A=B[24] VDD=VDD VSS=VSS
Xi_0_46 INV_X1 $PINS ZN=n_0_64 A=B[23] VDD=VDD VSS=VSS
Xi_0_63 OAI22_X1 $PINS ZN=n_0_31 A1=n_0_73 A2=adder_out[31] B1=A[31] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_62 AOI21_X1 $PINS ZN=O[31] A=n_0_31 B1=n_0_60 B2=n_0_72 VDD=VDD VSS=VSS
Xi_0_61 OAI22_X1 $PINS ZN=n_0_30 A1=n_0_73 A2=adder_out[30] B1=A[30] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_60 AOI21_X1 $PINS ZN=O[30] A=n_0_30 B1=n_0_60 B2=n_0_71 VDD=VDD VSS=VSS
Xi_0_59 OAI22_X1 $PINS ZN=n_0_29 A1=n_0_73 A2=adder_out[29] B1=A[29] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_58 AOI21_X1 $PINS ZN=O[29] A=n_0_29 B1=n_0_60 B2=n_0_70 VDD=VDD VSS=VSS
Xi_0_57 OAI22_X1 $PINS ZN=n_0_28 A1=n_0_73 A2=adder_out[28] B1=A[28] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_56 AOI21_X1 $PINS ZN=O[28] A=n_0_28 B1=n_0_60 B2=n_0_69 VDD=VDD VSS=VSS
Xi_0_55 OAI22_X1 $PINS ZN=n_0_27 A1=n_0_73 A2=adder_out[27] B1=A[27] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_54 AOI21_X1 $PINS ZN=O[27] A=n_0_27 B1=n_0_60 B2=n_0_68 VDD=VDD VSS=VSS
Xi_0_53 OAI22_X1 $PINS ZN=n_0_26 A1=n_0_73 A2=adder_out[26] B1=A[26] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_52 AOI21_X1 $PINS ZN=O[26] A=n_0_26 B1=n_0_60 B2=n_0_67 VDD=VDD VSS=VSS
Xi_0_51 OAI22_X1 $PINS ZN=n_0_25 A1=n_0_73 A2=adder_out[25] B1=A[25] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_50 AOI21_X1 $PINS ZN=O[25] A=n_0_25 B1=n_0_60 B2=n_0_66 VDD=VDD VSS=VSS
Xi_0_49 OAI22_X1 $PINS ZN=n_0_24 A1=n_0_73 A2=adder_out[24] B1=A[24] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_48 AOI21_X1 $PINS ZN=O[24] A=n_0_24 B1=n_0_60 B2=n_0_65 VDD=VDD VSS=VSS
Xi_0_3 OAI22_X1 $PINS ZN=n_0_23 A1=n_0_73 A2=adder_out[23] B1=A[23] B2=n_0_58
+ VDD=VDD VSS=VSS
Xi_0_2 AOI21_X1 $PINS ZN=O[23] A=n_0_23 B1=n_0_60 B2=n_0_64 VDD=VDD VSS=VSS
Xi_0_45 AOI222_X1 $PINS ZN=n_0_22 A1=adder_out[22] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[22] C1=A[22] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_44 INV_X1 $PINS ZN=O[22] A=n_0_22 VDD=VDD VSS=VSS
Xi_0_43 AOI222_X1 $PINS ZN=n_0_21 A1=adder_out[21] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[21] C1=A[21] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_42 INV_X1 $PINS ZN=O[21] A=n_0_21 VDD=VDD VSS=VSS
Xi_0_41 AOI222_X1 $PINS ZN=n_0_20 A1=adder_out[20] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[20] C1=A[20] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_40 INV_X1 $PINS ZN=O[20] A=n_0_20 VDD=VDD VSS=VSS
Xi_0_39 AOI222_X1 $PINS ZN=n_0_19 A1=adder_out[19] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[19] C1=A[19] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_38 INV_X1 $PINS ZN=O[19] A=n_0_19 VDD=VDD VSS=VSS
Xi_0_37 AOI222_X1 $PINS ZN=n_0_18 A1=adder_out[18] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[18] C1=A[18] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_36 INV_X1 $PINS ZN=O[18] A=n_0_18 VDD=VDD VSS=VSS
Xi_0_35 AOI222_X1 $PINS ZN=n_0_17 A1=adder_out[17] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[17] C1=A[17] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_34 INV_X1 $PINS ZN=O[17] A=n_0_17 VDD=VDD VSS=VSS
Xi_0_33 AOI222_X1 $PINS ZN=n_0_16 A1=adder_out[16] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[16] C1=A[16] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_32 INV_X1 $PINS ZN=O[16] A=n_0_16 VDD=VDD VSS=VSS
Xi_0_31 AOI222_X1 $PINS ZN=n_0_15 A1=adder_out[15] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[15] C1=A[15] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_30 INV_X1 $PINS ZN=O[15] A=n_0_15 VDD=VDD VSS=VSS
Xi_0_29 AOI222_X1 $PINS ZN=n_0_14 A1=adder_out[14] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[14] C1=A[14] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_28 INV_X1 $PINS ZN=O[14] A=n_0_14 VDD=VDD VSS=VSS
Xi_0_27 AOI222_X1 $PINS ZN=n_0_13 A1=adder_out[13] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[13] C1=A[13] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_26 INV_X1 $PINS ZN=O[13] A=n_0_13 VDD=VDD VSS=VSS
Xi_0_25 AOI222_X1 $PINS ZN=n_0_12 A1=adder_out[12] A2=hfn_ipo_n9 B1=n_0_60
+ B2=B[12] C1=A[12] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_24 INV_X1 $PINS ZN=O[12] A=n_0_12 VDD=VDD VSS=VSS
Xi_0_23 AOI222_X1 $PINS ZN=n_0_11 A1=adder_out[11] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[11] C1=A[11] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_22 INV_X1 $PINS ZN=O[11] A=n_0_11 VDD=VDD VSS=VSS
Xi_0_21 AOI222_X1 $PINS ZN=n_0_10 A1=adder_out[10] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[10] C1=A[10] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_20 INV_X1 $PINS ZN=O[10] A=n_0_10 VDD=VDD VSS=VSS
Xi_0_19 AOI222_X1 $PINS ZN=n_0_9 A1=adder_out[9] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[9] C1=A[9] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_18 INV_X1 $PINS ZN=O[9] A=n_0_9 VDD=VDD VSS=VSS
Xi_0_17 AOI222_X1 $PINS ZN=n_0_8 A1=adder_out[8] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[8] C1=A[8] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_16 INV_X1 $PINS ZN=O[8] A=n_0_8 VDD=VDD VSS=VSS
Xi_0_15 AOI222_X1 $PINS ZN=n_0_7 A1=adder_out[7] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[7] C1=A[7] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_14 INV_X1 $PINS ZN=O[7] A=n_0_7 VDD=VDD VSS=VSS
Xi_0_13 AOI222_X1 $PINS ZN=n_0_6 A1=adder_out[6] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[6] C1=A[6] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_12 INV_X1 $PINS ZN=O[6] A=n_0_6 VDD=VDD VSS=VSS
Xi_0_11 AOI222_X1 $PINS ZN=n_0_5 A1=adder_out[5] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[5] C1=A[5] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_10 INV_X1 $PINS ZN=O[5] A=n_0_5 VDD=VDD VSS=VSS
Xi_0_9 AOI222_X1 $PINS ZN=n_0_4 A1=adder_out[4] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[4] C1=A[4] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_8 INV_X1 $PINS ZN=O[4] A=n_0_4 VDD=VDD VSS=VSS
Xi_0_7 AOI222_X1 $PINS ZN=n_0_3 A1=adder_out[3] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[3] C1=A[3] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_6 INV_X1 $PINS ZN=O[3] A=n_0_3 VDD=VDD VSS=VSS
Xi_0_5 AOI222_X1 $PINS ZN=n_0_2 A1=adder_out[2] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[2] C1=A[2] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_4 INV_X1 $PINS ZN=O[2] A=n_0_2 VDD=VDD VSS=VSS
Xi_0_1 AOI222_X1 $PINS ZN=n_0_1 A1=adder_out[1] A2=hfn_ipo_n10 B1=n_0_60
+ B2=B[1] C1=A[1] C2=drc_ipo_n11 VDD=VDD VSS=VSS
Xi_0_0 INV_X1 $PINS ZN=O[1] A=n_0_1 VDD=VDD VSS=VSS
Xadder_a_in_reg[0] DLH_X1 $PINS Q=adder_a_in[0] D=A[0] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[1] DLH_X1 $PINS Q=adder_a_in[1] D=A[1] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[2] DLH_X1 $PINS Q=adder_a_in[2] D=A[2] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[3] DLH_X1 $PINS Q=adder_a_in[3] D=A[3] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[4] DLH_X1 $PINS Q=adder_a_in[4] D=A[4] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[5] DLH_X1 $PINS Q=adder_a_in[5] D=A[5] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[6] DLH_X1 $PINS Q=adder_a_in[6] D=A[6] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[7] DLH_X1 $PINS Q=adder_a_in[7] D=A[7] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[8] DLH_X1 $PINS Q=adder_a_in[8] D=A[8] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[9] DLH_X1 $PINS Q=adder_a_in[9] D=A[9] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[10] DLH_X1 $PINS Q=adder_a_in[10] D=A[10] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[11] DLH_X1 $PINS Q=adder_a_in[11] D=A[11] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[12] DLH_X1 $PINS Q=adder_a_in[12] D=A[12] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[13] DLH_X1 $PINS Q=adder_a_in[13] D=A[13] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[14] DLH_X1 $PINS Q=adder_a_in[14] D=A[14] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[15] DLH_X1 $PINS Q=adder_a_in[15] D=A[15] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[16] DLH_X1 $PINS Q=adder_a_in[16] D=A[16] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[17] DLH_X1 $PINS Q=adder_a_in[17] D=A[17] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[18] DLH_X1 $PINS Q=adder_a_in[18] D=A[18] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[19] DLH_X1 $PINS Q=adder_a_in[19] D=A[19] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[20] DLH_X1 $PINS Q=adder_a_in[20] D=A[20] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[21] DLH_X1 $PINS Q=adder_a_in[21] D=A[21] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[22] DLH_X1 $PINS Q=adder_a_in[22] D=A[22] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[23] DLH_X1 $PINS Q=adder_a_in[23] D=A[23] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[24] DLH_X1 $PINS Q=adder_a_in[24] D=A[24] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[25] DLH_X1 $PINS Q=adder_a_in[25] D=A[25] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[26] DLH_X1 $PINS Q=adder_a_in[26] D=A[26] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[27] DLH_X1 $PINS Q=adder_a_in[27] D=A[27] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[28] DLH_X1 $PINS Q=adder_a_in[28] D=A[28] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[29] DLH_X1 $PINS Q=adder_a_in[29] D=A[29] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[30] DLH_X1 $PINS Q=adder_a_in[30] D=A[30] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_a_in_reg[31] DLH_X1 $PINS Q=adder_a_in[31] D=A[31] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[0] DLH_X1 $PINS Q=adder_b_in[0] D=B[0] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[1] DLH_X1 $PINS Q=adder_b_in[1] D=B[1] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[2] DLH_X1 $PINS Q=adder_b_in[2] D=B[2] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[3] DLH_X1 $PINS Q=adder_b_in[3] D=B[3] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[4] DLH_X1 $PINS Q=adder_b_in[4] D=B[4] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[5] DLH_X1 $PINS Q=adder_b_in[5] D=B[5] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[6] DLH_X1 $PINS Q=adder_b_in[6] D=B[6] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[7] DLH_X1 $PINS Q=adder_b_in[7] D=B[7] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[8] DLH_X1 $PINS Q=adder_b_in[8] D=B[8] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[9] DLH_X1 $PINS Q=adder_b_in[9] D=B[9] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[10] DLH_X1 $PINS Q=adder_b_in[10] D=B[10] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[11] DLH_X1 $PINS Q=adder_b_in[11] D=B[11] G=hfn_ipo_n10 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[12] DLH_X1 $PINS Q=adder_b_in[12] D=B[12] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[13] DLH_X1 $PINS Q=adder_b_in[13] D=B[13] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[14] DLH_X1 $PINS Q=adder_b_in[14] D=B[14] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[15] DLH_X1 $PINS Q=adder_b_in[15] D=B[15] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[16] DLH_X1 $PINS Q=adder_b_in[16] D=B[16] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[17] DLH_X1 $PINS Q=adder_b_in[17] D=B[17] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[18] DLH_X1 $PINS Q=adder_b_in[18] D=B[18] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[19] DLH_X1 $PINS Q=adder_b_in[19] D=B[19] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[20] DLH_X1 $PINS Q=adder_b_in[20] D=B[20] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[21] DLH_X1 $PINS Q=adder_b_in[21] D=B[21] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[22] DLH_X1 $PINS Q=adder_b_in[22] D=B[22] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[23] DLH_X1 $PINS Q=adder_b_in[23] D=B[23] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[24] DLH_X1 $PINS Q=adder_b_in[24] D=B[24] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[25] DLH_X1 $PINS Q=adder_b_in[25] D=B[25] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[26] DLH_X1 $PINS Q=adder_b_in[26] D=B[26] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[27] DLH_X1 $PINS Q=adder_b_in[27] D=B[27] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[28] DLH_X1 $PINS Q=adder_b_in[28] D=B[28] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[29] DLH_X1 $PINS Q=adder_b_in[29] D=B[29] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[30] DLH_X1 $PINS Q=adder_b_in[30] D=B[30] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
Xadder_b_in_reg[31] DLH_X1 $PINS Q=adder_b_in[31] D=B[31] G=hfn_ipo_n9 VDD=VDD
+ VSS=VSS
XA1 adder $PINS of=OF out[31]=adder_out[31] out[30]=adder_out[30]
+ out[29]=adder_out[29] out[28]=adder_out[28] out[27]=adder_out[27]
+ out[26]=adder_out[26] out[25]=adder_out[25] out[24]=adder_out[24]
+ out[23]=adder_out[23] out[22]=adder_out[22] out[21]=adder_out[21]
+ out[20]=adder_out[20] out[19]=adder_out[19] out[18]=adder_out[18]
+ out[17]=adder_out[17] out[16]=adder_out[16] out[15]=adder_out[15]
+ out[14]=adder_out[14] out[13]=adder_out[13] out[12]=adder_out[12]
+ out[11]=adder_out[11] out[10]=adder_out[10] out[9]=adder_out[9]
+ out[8]=adder_out[8] out[7]=adder_out[7] out[6]=adder_out[6] out[5]=adder_out[5]
+ out[4]=adder_out[4] out[3]=adder_out[3] out[2]=adder_out[2] out[1]=adder_out[1]
+ out[0]=adder_out[0] a[31]=adder_a_in[31] a[30]=adder_a_in[30]
+ a[29]=adder_a_in[29] a[28]=adder_a_in[28] a[27]=adder_a_in[27]
+ a[26]=adder_a_in[26] a[25]=adder_a_in[25] a[24]=adder_a_in[24]
+ a[23]=adder_a_in[23] a[22]=adder_a_in[22] a[21]=adder_a_in[21]
+ a[20]=adder_a_in[20] a[19]=adder_a_in[19] a[18]=adder_a_in[18]
+ a[17]=adder_a_in[17] a[16]=adder_a_in[16] a[15]=adder_a_in[15]
+ a[14]=adder_a_in[14] a[13]=adder_a_in[13] a[12]=adder_a_in[12]
+ a[11]=adder_a_in[11] a[10]=adder_a_in[10] a[9]=adder_a_in[9] a[8]=adder_a_in[8]
+ a[7]=adder_a_in[7] a[6]=adder_a_in[6] a[5]=adder_a_in[5] a[4]=adder_a_in[4]
+ a[3]=adder_a_in[3] a[2]=adder_a_in[2] a[1]=adder_a_in[1] a[0]=adder_a_in[0]
+ b[31]=adder_b_in[31] b[30]=adder_b_in[30] b[29]=adder_b_in[29]
+ b[28]=adder_b_in[28] b[27]=adder_b_in[27] b[26]=adder_b_in[26]
+ b[25]=adder_b_in[25] b[24]=adder_b_in[24] b[23]=adder_b_in[23]
+ b[22]=adder_b_in[22] b[21]=adder_b_in[21] b[20]=adder_b_in[20]
+ b[19]=adder_b_in[19] b[18]=adder_b_in[18] b[17]=adder_b_in[17]
+ b[16]=adder_b_in[16] b[15]=adder_b_in[15] b[14]=adder_b_in[14]
+ b[13]=adder_b_in[13] b[12]=adder_b_in[12] b[11]=adder_b_in[11]
+ b[10]=adder_b_in[10] b[9]=adder_b_in[9] b[8]=adder_b_in[8] b[7]=adder_b_in[7]
+ b[6]=adder_b_in[6] b[5]=adder_b_in[5] b[4]=adder_b_in[4] b[3]=adder_b_in[3]
+ b[2]=adder_b_in[2] b[1]=adder_b_in[1] b[0]=adder_b_in[0] VDD=VDD VSS=VSS
Xhfn_ipo_c10 BUF_X2 $PINS Z=hfn_ipo_n10 A=n_0 VDD=VDD VSS=VSS
Xdrc_ipo_c11 CLKBUF_X1 $PINS Z=drc_ipo_n11 A=n_0_44 VDD=VDD VSS=VSS
Xhfn_ipo_c9 BUF_X2 $PINS Z=hfn_ipo_n9 A=n_0 VDD=VDD VSS=VSS
.ENDS

.SUBCKT registerNbits__0_106 clk_CTSPP_1 VDD VSS clk reset en inp[31] inp[30]
+ inp[29] inp[28] inp[27] inp[26] inp[25] inp[24] inp[23] inp[22] inp[21]
+ inp[20] inp[19] inp[18] inp[17] inp[16] inp[15] inp[14] inp[13] inp[12]
+ inp[11] inp[10] inp[9] inp[8] inp[7] inp[6] inp[5] inp[4] inp[3] inp[2]
+ inp[1] inp[0] out[31] out[30] out[29] out[28] out[27] out[26] out[25] out[24]
+ out[23] out[22] out[21] out[20] out[19] out[18] out[17] out[16] out[15]
+ out[14] out[13] out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5]
+ out[4] out[3] out[2] out[1] out[0]
Xi_0_33 AND2_X1 $PINS ZN=CLOCK_slh__n90 A1=n_0_0 A2=inp[31] VDD=VDD VSS=VSS
Xi_0_32 AND2_X1 $PINS ZN=CLOCK_slh__n70 A1=n_0_0 A2=inp[30] VDD=VDD VSS=VSS
Xi_0_31 AND2_X1 $PINS ZN=CLOCK_slh__n84 A1=n_0_0 A2=inp[29] VDD=VDD VSS=VSS
Xi_0_30 AND2_X1 $PINS ZN=CLOCK_slh__n82 A1=n_0_0 A2=inp[28] VDD=VDD VSS=VSS
Xi_0_29 AND2_X1 $PINS ZN=CLOCK_slh__n80 A1=n_0_0 A2=inp[27] VDD=VDD VSS=VSS
Xi_0_28 AND2_X1 $PINS ZN=CLOCK_slh__n86 A1=n_0_0 A2=inp[26] VDD=VDD VSS=VSS
Xi_0_27 AND2_X1 $PINS ZN=CLOCK_slh__n68 A1=n_0_0 A2=inp[25] VDD=VDD VSS=VSS
Xi_0_26 AND2_X1 $PINS ZN=CLOCK_slh__n72 A1=n_0_0 A2=inp[24] VDD=VDD VSS=VSS
Xi_0_25 AND2_X1 $PINS ZN=CLOCK_slh__n78 A1=n_0_0 A2=inp[23] VDD=VDD VSS=VSS
Xi_0_24 AND2_X1 $PINS ZN=CLOCK_slh__n76 A1=n_0_0 A2=inp[22] VDD=VDD VSS=VSS
Xi_0_23 AND2_X1 $PINS ZN=CLOCK_slh__n74 A1=n_0_0 A2=inp[21] VDD=VDD VSS=VSS
Xi_0_22 AND2_X1 $PINS ZN=CLOCK_slh__n92 A1=n_0_0 A2=inp[20] VDD=VDD VSS=VSS
Xi_0_21 AND2_X1 $PINS ZN=CLOCK_slh__n88 A1=n_0_0 A2=inp[19] VDD=VDD VSS=VSS
Xi_0_20 AND2_X1 $PINS ZN=CLOCK_slh__n96 A1=n_0_0 A2=inp[18] VDD=VDD VSS=VSS
Xi_0_19 AND2_X1 $PINS ZN=CLOCK_slh__n94 A1=n_0_0 A2=inp[17] VDD=VDD VSS=VSS
Xi_0_18 AND2_X1 $PINS ZN=n_18 A1=n_0_0 A2=inp[16] VDD=VDD VSS=VSS
Xi_0_17 AND2_X1 $PINS ZN=n_17 A1=n_0_0 A2=inp[15] VDD=VDD VSS=VSS
Xi_0_16 AND2_X1 $PINS ZN=n_16 A1=n_0_0 A2=inp[14] VDD=VDD VSS=VSS
Xi_0_15 AND2_X1 $PINS ZN=n_15 A1=n_0_0 A2=inp[13] VDD=VDD VSS=VSS
Xi_0_14 AND2_X1 $PINS ZN=n_14 A1=n_0_0 A2=inp[12] VDD=VDD VSS=VSS
Xi_0_13 AND2_X1 $PINS ZN=n_13 A1=n_0_0 A2=inp[11] VDD=VDD VSS=VSS
Xi_0_12 AND2_X1 $PINS ZN=n_12 A1=n_0_0 A2=inp[10] VDD=VDD VSS=VSS
Xi_0_11 AND2_X1 $PINS ZN=n_11 A1=n_0_0 A2=inp[9] VDD=VDD VSS=VSS
Xi_0_10 AND2_X1 $PINS ZN=n_10 A1=n_0_0 A2=inp[8] VDD=VDD VSS=VSS
Xi_0_9 AND2_X1 $PINS ZN=n_9 A1=n_0_0 A2=inp[7] VDD=VDD VSS=VSS
Xi_0_8 AND2_X1 $PINS ZN=n_8 A1=n_0_0 A2=inp[6] VDD=VDD VSS=VSS
Xi_0_7 AND2_X1 $PINS ZN=n_7 A1=n_0_0 A2=inp[5] VDD=VDD VSS=VSS
Xi_0_6 AND2_X1 $PINS ZN=n_6 A1=n_0_0 A2=inp[4] VDD=VDD VSS=VSS
Xi_0_5 AND2_X1 $PINS ZN=n_5 A1=n_0_0 A2=inp[3] VDD=VDD VSS=VSS
Xi_0_4 AND2_X1 $PINS ZN=n_4 A1=n_0_0 A2=inp[2] VDD=VDD VSS=VSS
Xi_0_3 AND2_X1 $PINS ZN=n_3 A1=n_0_0 A2=inp[1] VDD=VDD VSS=VSS
Xi_0_2 AND2_X1 $PINS ZN=n_2 A1=n_0_0 A2=inp[0] VDD=VDD VSS=VSS
Xi_0_1 INV_X2 $PINS ZN=n_0_0 A=reset VDD=VDD VSS=VSS
Xi_0_0 OR2_X1 $PINS ZN=n_1 A1=en A2=reset VDD=VDD VSS=VSS
Xout_reg[0] DFF_X1 $PINS Q=out[0] CK=CTS_n2 D=n_2 VDD=VDD VSS=VSS
Xout_reg[1] DFF_X1 $PINS Q=out[1] CK=CTS_n2 D=n_3 VDD=VDD VSS=VSS
Xout_reg[2] DFF_X1 $PINS Q=out[2] CK=CTS_n2 D=n_4 VDD=VDD VSS=VSS
Xout_reg[3] DFF_X1 $PINS Q=out[3] CK=CTS_n2 D=n_5 VDD=VDD VSS=VSS
Xout_reg[4] DFF_X1 $PINS Q=out[4] CK=CTS_n2 D=n_6 VDD=VDD VSS=VSS
Xout_reg[5] DFF_X1 $PINS Q=out[5] CK=CTS_n2 D=n_7 VDD=VDD VSS=VSS
Xout_reg[6] DFF_X1 $PINS Q=out[6] CK=CTS_n2 D=n_8 VDD=VDD VSS=VSS
Xout_reg[7] DFF_X1 $PINS Q=out[7] CK=CTS_n2 D=n_9 VDD=VDD VSS=VSS
Xout_reg[8] DFF_X1 $PINS Q=out[8] CK=CTS_n2 D=n_10 VDD=VDD VSS=VSS
Xout_reg[9] DFF_X1 $PINS Q=out[9] CK=CTS_n2 D=n_11 VDD=VDD VSS=VSS
Xout_reg[10] DFF_X1 $PINS Q=out[10] CK=CTS_n2 D=n_12 VDD=VDD VSS=VSS
Xout_reg[11] DFF_X1 $PINS Q=out[11] CK=CTS_n2 D=n_13 VDD=VDD VSS=VSS
Xout_reg[12] DFF_X1 $PINS Q=out[12] CK=CTS_n2 D=n_14 VDD=VDD VSS=VSS
Xout_reg[13] DFF_X1 $PINS Q=out[13] CK=CTS_n2 D=n_15 VDD=VDD VSS=VSS
Xout_reg[14] DFF_X1 $PINS Q=out[14] CK=CTS_n2 D=n_16 VDD=VDD VSS=VSS
Xout_reg[15] DFF_X1 $PINS Q=out[15] CK=CTS_n2 D=n_17 VDD=VDD VSS=VSS
Xout_reg[16] DFF_X1 $PINS Q=out[16] CK=CTS_n2 D=n_18 VDD=VDD VSS=VSS
Xout_reg[17] DFF_X1 $PINS Q=out[17] CK=CTS_n2 D=n_19 VDD=VDD VSS=VSS
Xout_reg[18] DFF_X1 $PINS Q=out[18] CK=CTS_n2 D=n_20 VDD=VDD VSS=VSS
Xout_reg[19] DFF_X1 $PINS Q=out[19] CK=CTS_n2 D=n_21 VDD=VDD VSS=VSS
Xout_reg[20] DFF_X1 $PINS Q=out[20] CK=CTS_n2 D=n_22 VDD=VDD VSS=VSS
Xout_reg[21] DFF_X1 $PINS Q=out[21] CK=CTS_n2 D=n_23 VDD=VDD VSS=VSS
Xout_reg[22] DFF_X1 $PINS Q=out[22] CK=CTS_n2 D=n_24 VDD=VDD VSS=VSS
Xout_reg[23] DFF_X1 $PINS Q=out[23] CK=CTS_n2 D=n_25 VDD=VDD VSS=VSS
Xout_reg[24] DFF_X1 $PINS Q=out[24] CK=CTS_n2 D=n_26 VDD=VDD VSS=VSS
Xout_reg[25] DFF_X1 $PINS Q=out[25] CK=CTS_n2 D=n_27 VDD=VDD VSS=VSS
Xout_reg[26] DFF_X1 $PINS Q=out[26] CK=CTS_n2 D=n_28 VDD=VDD VSS=VSS
Xout_reg[27] DFF_X1 $PINS Q=out[27] CK=CTS_n2 D=n_29 VDD=VDD VSS=VSS
Xout_reg[28] DFF_X1 $PINS Q=out[28] CK=CTS_n2 D=n_30 VDD=VDD VSS=VSS
Xout_reg[29] DFF_X1 $PINS Q=out[29] CK=CTS_n2 D=n_31 VDD=VDD VSS=VSS
Xout_reg[30] DFF_X1 $PINS Q=out[30] CK=CTS_n2 D=n_32 VDD=VDD VSS=VSS
Xout_reg[31] DFF_X1 $PINS Q=out[31] CK=CTS_n2 D=n_33 VDD=VDD VSS=VSS
Xclk_gate_out_reg CLKGATETST_X8 $PINS GCK=CTS_n3 CK=clk_CTSPP_1 E=n_1 SE=VSS
+ VDD=VDD VSS=VSS
XCTS_L3_c3 CLKBUF_X3 $PINS Z=CTS_n2 A=CTS_n3 VDD=VDD VSS=VSS
XCLOCK_slh__c37 CLKBUF_X1 $PINS Z=n_27 A=CLOCK_slh__n68 VDD=VDD VSS=VSS
XCLOCK_slh__c39 CLKBUF_X1 $PINS Z=n_32 A=CLOCK_slh__n70 VDD=VDD VSS=VSS
XCLOCK_slh__c41 CLKBUF_X1 $PINS Z=n_26 A=CLOCK_slh__n72 VDD=VDD VSS=VSS
XCLOCK_slh__c43 CLKBUF_X1 $PINS Z=n_23 A=CLOCK_slh__n74 VDD=VDD VSS=VSS
XCLOCK_slh__c45 CLKBUF_X1 $PINS Z=n_24 A=CLOCK_slh__n76 VDD=VDD VSS=VSS
XCLOCK_slh__c47 CLKBUF_X1 $PINS Z=n_25 A=CLOCK_slh__n78 VDD=VDD VSS=VSS
XCLOCK_slh__c49 CLKBUF_X1 $PINS Z=n_29 A=CLOCK_slh__n80 VDD=VDD VSS=VSS
XCLOCK_slh__c51 CLKBUF_X1 $PINS Z=n_30 A=CLOCK_slh__n82 VDD=VDD VSS=VSS
XCLOCK_slh__c53 CLKBUF_X1 $PINS Z=n_31 A=CLOCK_slh__n84 VDD=VDD VSS=VSS
XCLOCK_slh__c55 CLKBUF_X1 $PINS Z=n_28 A=CLOCK_slh__n86 VDD=VDD VSS=VSS
XCLOCK_slh__c57 CLKBUF_X1 $PINS Z=n_21 A=CLOCK_slh__n88 VDD=VDD VSS=VSS
XCLOCK_slh__c59 CLKBUF_X1 $PINS Z=n_33 A=CLOCK_slh__n90 VDD=VDD VSS=VSS
XCLOCK_slh__c61 CLKBUF_X1 $PINS Z=n_22 A=CLOCK_slh__n92 VDD=VDD VSS=VSS
XCLOCK_slh__c63 CLKBUF_X1 $PINS Z=n_19 A=CLOCK_slh__n94 VDD=VDD VSS=VSS
XCLOCK_slh__c65 CLKBUF_X1 $PINS Z=n_20 A=CLOCK_slh__n96 VDD=VDD VSS=VSS
.ENDS

.SUBCKT registerNbits__0_103 clk_CTSPP_2 VDD VSS clk reset en inp[31] inp[30]
+ inp[29] inp[28] inp[27] inp[26] inp[25] inp[24] inp[23] inp[22] inp[21]
+ inp[20] inp[19] inp[18] inp[17] inp[16] inp[15] inp[14] inp[13] inp[12]
+ inp[11] inp[10] inp[9] inp[8] inp[7] inp[6] inp[5] inp[4] inp[3] inp[2]
+ inp[1] inp[0] out[31] out[30] out[29] out[28] out[27] out[26] out[25] out[24]
+ out[23] out[22] out[21] out[20] out[19] out[18] out[17] out[16] out[15]
+ out[14] out[13] out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5]
+ out[4] out[3] out[2] out[1] out[0]
Xi_0_33 AND2_X1 $PINS ZN=n_33 A1=n_0_0 A2=inp[31] VDD=VDD VSS=VSS
Xi_0_32 AND2_X1 $PINS ZN=n_32 A1=n_0_0 A2=inp[30] VDD=VDD VSS=VSS
Xi_0_31 AND2_X1 $PINS ZN=n_31 A1=n_0_0 A2=inp[29] VDD=VDD VSS=VSS
Xi_0_30 AND2_X1 $PINS ZN=n_30 A1=n_0_0 A2=inp[28] VDD=VDD VSS=VSS
Xi_0_29 AND2_X1 $PINS ZN=n_29 A1=n_0_0 A2=inp[27] VDD=VDD VSS=VSS
Xi_0_28 AND2_X1 $PINS ZN=n_28 A1=n_0_0 A2=inp[26] VDD=VDD VSS=VSS
Xi_0_27 AND2_X1 $PINS ZN=n_27 A1=n_0_0 A2=inp[25] VDD=VDD VSS=VSS
Xi_0_26 AND2_X1 $PINS ZN=n_26 A1=n_0_0 A2=inp[24] VDD=VDD VSS=VSS
Xi_0_25 AND2_X1 $PINS ZN=n_25 A1=n_0_0 A2=inp[23] VDD=VDD VSS=VSS
Xi_0_24 AND2_X1 $PINS ZN=n_24 A1=n_0_0 A2=inp[22] VDD=VDD VSS=VSS
Xi_0_23 AND2_X1 $PINS ZN=n_23 A1=n_0_0 A2=inp[21] VDD=VDD VSS=VSS
Xi_0_22 AND2_X1 $PINS ZN=n_22 A1=n_0_0 A2=inp[20] VDD=VDD VSS=VSS
Xi_0_21 AND2_X1 $PINS ZN=n_21 A1=n_0_0 A2=inp[19] VDD=VDD VSS=VSS
Xi_0_20 AND2_X1 $PINS ZN=n_20 A1=n_0_0 A2=inp[18] VDD=VDD VSS=VSS
Xi_0_19 AND2_X1 $PINS ZN=n_19 A1=n_0_0 A2=inp[17] VDD=VDD VSS=VSS
Xi_0_18 AND2_X1 $PINS ZN=n_18 A1=n_0_0 A2=inp[16] VDD=VDD VSS=VSS
Xi_0_17 AND2_X1 $PINS ZN=n_17 A1=n_0_0 A2=inp[15] VDD=VDD VSS=VSS
Xi_0_16 AND2_X1 $PINS ZN=n_16 A1=n_0_0 A2=inp[14] VDD=VDD VSS=VSS
Xi_0_15 AND2_X1 $PINS ZN=n_15 A1=n_0_0 A2=inp[13] VDD=VDD VSS=VSS
Xi_0_14 AND2_X1 $PINS ZN=n_14 A1=n_0_0 A2=inp[12] VDD=VDD VSS=VSS
Xi_0_13 AND2_X1 $PINS ZN=n_13 A1=n_0_0 A2=inp[11] VDD=VDD VSS=VSS
Xi_0_12 AND2_X1 $PINS ZN=n_12 A1=n_0_0 A2=inp[10] VDD=VDD VSS=VSS
Xi_0_11 AND2_X1 $PINS ZN=n_11 A1=n_0_0 A2=inp[9] VDD=VDD VSS=VSS
Xi_0_10 AND2_X1 $PINS ZN=n_10 A1=n_0_0 A2=inp[8] VDD=VDD VSS=VSS
Xi_0_9 AND2_X1 $PINS ZN=n_9 A1=n_0_0 A2=inp[7] VDD=VDD VSS=VSS
Xi_0_8 AND2_X1 $PINS ZN=n_8 A1=n_0_0 A2=inp[6] VDD=VDD VSS=VSS
Xi_0_7 AND2_X1 $PINS ZN=n_7 A1=n_0_0 A2=inp[5] VDD=VDD VSS=VSS
Xi_0_6 AND2_X1 $PINS ZN=n_6 A1=n_0_0 A2=inp[4] VDD=VDD VSS=VSS
Xi_0_5 AND2_X1 $PINS ZN=n_5 A1=n_0_0 A2=inp[3] VDD=VDD VSS=VSS
Xi_0_4 AND2_X1 $PINS ZN=n_4 A1=n_0_0 A2=inp[2] VDD=VDD VSS=VSS
Xi_0_3 AND2_X1 $PINS ZN=n_3 A1=n_0_0 A2=inp[1] VDD=VDD VSS=VSS
Xi_0_2 AND2_X1 $PINS ZN=n_2 A1=n_0_0 A2=inp[0] VDD=VDD VSS=VSS
Xi_0_1 INV_X1 $PINS ZN=n_0_0 A=reset VDD=VDD VSS=VSS
Xi_0_0 OR2_X1 $PINS ZN=n_1 A1=en A2=reset VDD=VDD VSS=VSS
Xout_reg[0] DFF_X1 $PINS Q=out[0] CK=CTS_n2 D=n_2 VDD=VDD VSS=VSS
Xout_reg[1] DFF_X1 $PINS Q=out[1] CK=CTS_n2 D=n_3 VDD=VDD VSS=VSS
Xout_reg[2] DFF_X1 $PINS Q=out[2] CK=CTS_n2 D=n_4 VDD=VDD VSS=VSS
Xout_reg[3] DFF_X1 $PINS Q=out[3] CK=CTS_n2 D=n_5 VDD=VDD VSS=VSS
Xout_reg[4] DFF_X1 $PINS Q=out[4] CK=CTS_n2 D=n_6 VDD=VDD VSS=VSS
Xout_reg[5] DFF_X1 $PINS Q=out[5] CK=CTS_n2 D=n_7 VDD=VDD VSS=VSS
Xout_reg[6] DFF_X1 $PINS Q=out[6] CK=CTS_n2 D=n_8 VDD=VDD VSS=VSS
Xout_reg[7] DFF_X1 $PINS Q=out[7] CK=CTS_n2 D=n_9 VDD=VDD VSS=VSS
Xout_reg[8] DFF_X1 $PINS Q=out[8] CK=CTS_n2 D=n_10 VDD=VDD VSS=VSS
Xout_reg[9] DFF_X1 $PINS Q=out[9] CK=CTS_n2 D=n_11 VDD=VDD VSS=VSS
Xout_reg[10] DFF_X1 $PINS Q=out[10] CK=CTS_n2 D=n_12 VDD=VDD VSS=VSS
Xout_reg[11] DFF_X1 $PINS Q=out[11] CK=CTS_n2 D=n_13 VDD=VDD VSS=VSS
Xout_reg[12] DFF_X1 $PINS Q=out[12] CK=CTS_n2 D=n_14 VDD=VDD VSS=VSS
Xout_reg[13] DFF_X1 $PINS Q=out[13] CK=CTS_n2 D=n_15 VDD=VDD VSS=VSS
Xout_reg[14] DFF_X1 $PINS Q=out[14] CK=CTS_n2 D=n_16 VDD=VDD VSS=VSS
Xout_reg[15] DFF_X1 $PINS Q=out[15] CK=CTS_n2 D=n_17 VDD=VDD VSS=VSS
Xout_reg[16] DFF_X1 $PINS Q=out[16] CK=CTS_n2 D=n_18 VDD=VDD VSS=VSS
Xout_reg[17] DFF_X1 $PINS Q=out[17] CK=CTS_n2 D=n_19 VDD=VDD VSS=VSS
Xout_reg[18] DFF_X1 $PINS Q=out[18] CK=CTS_n2 D=n_20 VDD=VDD VSS=VSS
Xout_reg[19] DFF_X1 $PINS Q=out[19] CK=CTS_n2 D=n_21 VDD=VDD VSS=VSS
Xout_reg[20] DFF_X1 $PINS Q=out[20] CK=CTS_n2 D=n_22 VDD=VDD VSS=VSS
Xout_reg[21] DFF_X1 $PINS Q=out[21] CK=CTS_n2 D=n_23 VDD=VDD VSS=VSS
Xout_reg[22] DFF_X1 $PINS Q=out[22] CK=CTS_n2 D=n_24 VDD=VDD VSS=VSS
Xout_reg[23] DFF_X1 $PINS Q=out[23] CK=CTS_n2 D=n_25 VDD=VDD VSS=VSS
Xout_reg[24] DFF_X1 $PINS Q=out[24] CK=CTS_n2 D=n_26 VDD=VDD VSS=VSS
Xout_reg[25] DFF_X1 $PINS Q=out[25] CK=CTS_n2 D=n_27 VDD=VDD VSS=VSS
Xout_reg[26] DFF_X1 $PINS Q=out[26] CK=CTS_n2 D=n_28 VDD=VDD VSS=VSS
Xout_reg[27] DFF_X1 $PINS Q=out[27] CK=CTS_n2 D=n_29 VDD=VDD VSS=VSS
Xout_reg[28] DFF_X1 $PINS Q=out[28] CK=CTS_n2 D=n_30 VDD=VDD VSS=VSS
Xout_reg[29] DFF_X1 $PINS Q=out[29] CK=CTS_n2 D=n_31 VDD=VDD VSS=VSS
Xout_reg[30] DFF_X1 $PINS Q=out[30] CK=CTS_n2 D=n_32 VDD=VDD VSS=VSS
Xout_reg[31] DFF_X1 $PINS Q=out[31] CK=CTS_n2 D=n_33 VDD=VDD VSS=VSS
Xclk_gate_out_reg CLKGATETST_X8 $PINS GCK=CTS_n3 CK=clk_CTSPP_2 E=n_1 SE=VSS
+ VDD=VDD VSS=VSS
XCTS_L3_c3 CLKBUF_X3 $PINS Z=CTS_n2 A=CTS_n3 VDD=VDD VSS=VSS
.ENDS

.SUBCKT fpa_with_regisers VSS VDD clk reset en inputA[31] inputA[30] inputA[29]
+ inputA[28] inputA[27] inputA[26] inputA[25] inputA[24] inputA[23] inputA[22]
+ inputA[21] inputA[20] inputA[19] inputA[18] inputA[17] inputA[16] inputA[15]
+ inputA[14] inputA[13] inputA[12] inputA[11] inputA[10] inputA[9] inputA[8]
+ inputA[7] inputA[6] inputA[5] inputA[4] inputA[3] inputA[2] inputA[1]
+ inputA[0] inputB[31] inputB[30] inputB[29] inputB[28] inputB[27] inputB[26]
+ inputB[25] inputB[24] inputB[23] inputB[22] inputB[21] inputB[20] inputB[19]
+ inputB[18] inputB[17] inputB[16] inputB[15] inputB[14] inputB[13] inputB[12]
+ inputB[11] inputB[10] inputB[9] inputB[8] inputB[7] inputB[6] inputB[5]
+ inputB[4] inputB[3] inputB[2] inputB[1] inputB[0] result[31] result[30]
+ result[29] result[28] result[27] result[26] result[25] result[24] result[23]
+ result[22] result[21] result[20] result[19] result[18] result[17] result[16]
+ result[15] result[14] result[13] result[12] result[11] result[10] result[9]
+ result[8] result[7] result[6] result[5] result[4] result[3] result[2]
+ result[1] result[0] OF
XoutReg registerNbits $PINS out[31]=result[31] out[30]=result[30]
+ out[29]=result[29] out[28]=result[28] out[27]=result[27] out[26]=result[26]
+ out[25]=result[25] out[24]=result[24] out[23]=result[23] out[22]=result[22]
+ out[21]=result[21] out[20]=result[20] out[19]=result[19] out[18]=result[18]
+ out[17]=result[17] out[16]=result[16] out[15]=result[15] out[14]=result[14]
+ out[13]=result[13] out[12]=result[12] out[11]=result[11] out[10]=result[10]
+ out[9]=result[9] out[8]=result[8] out[7]=result[7] out[6]=result[6]
+ out[5]=result[5] out[4]=result[4] out[3]=result[3] out[2]=result[2]
+ out[1]=result[1] out[0]=result[0] en=en inp[31]=out[31] inp[30]=out[30]
+ inp[29]=out[29] inp[28]=out[28] inp[27]=out[27] inp[26]=out[26] inp[25]=out[25]
+ inp[24]=out[24] inp[23]=out[23] inp[22]=out[22] inp[21]=out[21] inp[20]=out[20]
+ inp[19]=out[19] inp[18]=out[18] inp[17]=out[17] inp[16]=out[16] inp[15]=out[15]
+ inp[14]=out[14] inp[13]=out[13] inp[12]=out[12] inp[11]=out[11] inp[10]=out[10]
+ inp[9]=out[9] inp[8]=out[8] inp[7]=out[7] inp[6]=out[6] inp[5]=out[5]
+ inp[4]=out[4] inp[3]=out[3] inp[2]=out[2] inp[1]=out[1] inp[0]=out[0]
+ reset=reset clk_CTSPP_1=CLOCK_n33 VDD=VDD VSS=VSS
Xfpa_obj fpa $PINS OF=OF O[31]=out[31] O[30]=out[30] O[29]=out[29]
+ O[28]=out[28] O[27]=out[27] O[26]=out[26] O[25]=out[25] O[24]=out[24]
+ O[23]=out[23] O[22]=out[22] O[21]=out[21] O[20]=out[20] O[19]=out[19]
+ O[18]=out[18] O[17]=out[17] O[16]=out[16] O[15]=out[15] O[14]=out[14]
+ O[13]=out[13] O[12]=out[12] O[11]=out[11] O[10]=out[10] O[9]=out[9] O[8]=out[8]
+ O[7]=out[7] O[6]=out[6] O[5]=out[5] O[4]=out[4] O[3]=out[3] O[2]=out[2]
+ O[1]=out[1] O[0]=out[0] A[31]=A_reg[31] A[30]=A_reg[30] A[29]=A_reg[29]
+ A[28]=A_reg[28] A[27]=A_reg[27] A[26]=A_reg[26] A[25]=A_reg[25] A[24]=A_reg[24]
+ A[23]=A_reg[23] A[22]=A_reg[22] A[21]=A_reg[21] A[20]=A_reg[20] A[19]=A_reg[19]
+ A[18]=A_reg[18] A[17]=A_reg[17] A[16]=A_reg[16] A[15]=A_reg[15] A[14]=A_reg[14]
+ A[13]=A_reg[13] A[12]=A_reg[12] A[11]=A_reg[11] A[10]=A_reg[10] A[9]=A_reg[9]
+ A[8]=A_reg[8] A[7]=A_reg[7] A[6]=A_reg[6] A[5]=A_reg[5] A[4]=A_reg[4]
+ A[3]=A_reg[3] A[2]=A_reg[2] A[1]=A_reg[1] A[0]=A_reg[0] B[31]=B_reg[31]
+ B[30]=B_reg[30] B[29]=B_reg[29] B[28]=B_reg[28] B[27]=B_reg[27] B[26]=B_reg[26]
+ B[25]=B_reg[25] B[24]=B_reg[24] B[23]=B_reg[23] B[22]=B_reg[22] B[21]=B_reg[21]
+ B[20]=B_reg[20] B[19]=B_reg[19] B[18]=B_reg[18] B[17]=B_reg[17] B[16]=B_reg[16]
+ B[15]=B_reg[15] B[14]=B_reg[14] B[13]=B_reg[13] B[12]=B_reg[12] B[11]=B_reg[11]
+ B[10]=B_reg[10] B[9]=B_reg[9] B[8]=B_reg[8] B[7]=B_reg[7] B[6]=B_reg[6]
+ B[5]=B_reg[5] B[4]=B_reg[4] B[3]=B_reg[3] B[2]=B_reg[2] B[1]=B_reg[1]
+ B[0]=B_reg[0] VDD=VDD VSS=VSS
XregB registerNbits__0_106 $PINS out[31]=B_reg[31] out[30]=B_reg[30]
+ out[29]=B_reg[29] out[28]=B_reg[28] out[27]=B_reg[27] out[26]=B_reg[26]
+ out[25]=B_reg[25] out[24]=B_reg[24] out[23]=B_reg[23] out[22]=B_reg[22]
+ out[21]=B_reg[21] out[20]=B_reg[20] out[19]=B_reg[19] out[18]=B_reg[18]
+ out[17]=B_reg[17] out[16]=B_reg[16] out[15]=B_reg[15] out[14]=B_reg[14]
+ out[13]=B_reg[13] out[12]=B_reg[12] out[11]=B_reg[11] out[10]=B_reg[10]
+ out[9]=B_reg[9] out[8]=B_reg[8] out[7]=B_reg[7] out[6]=B_reg[6] out[5]=B_reg[5]
+ out[4]=B_reg[4] out[3]=B_reg[3] out[2]=B_reg[2] out[1]=B_reg[1] out[0]=B_reg[0]
+ en=en inp[31]=inputB[31] inp[30]=inputB[30] inp[29]=inputB[29]
+ inp[28]=inputB[28] inp[27]=inputB[27] inp[26]=inputB[26] inp[25]=inputB[25]
+ inp[24]=inputB[24] inp[23]=inputB[23] inp[22]=inputB[22] inp[21]=inputB[21]
+ inp[20]=inputB[20] inp[19]=inputB[19] inp[18]=inputB[18] inp[17]=inputB[17]
+ inp[16]=inputB[16] inp[15]=inputB[15] inp[14]=inputB[14] inp[13]=inputB[13]
+ inp[12]=inputB[12] inp[11]=inputB[11] inp[10]=inputB[10] inp[9]=inputB[9]
+ inp[8]=inputB[8] inp[7]=inputB[7] inp[6]=inputB[6] inp[5]=inputB[5]
+ inp[4]=inputB[4] inp[3]=inputB[3] inp[2]=inputB[2] inp[1]=inputB[1]
+ inp[0]=inputB[0] reset=reset clk_CTSPP_1=CLOCK_n33 VDD=VDD VSS=VSS
XregA registerNbits__0_103 $PINS out[31]=A_reg[31] out[30]=A_reg[30]
+ out[29]=A_reg[29] out[28]=A_reg[28] out[27]=A_reg[27] out[26]=A_reg[26]
+ out[25]=A_reg[25] out[24]=A_reg[24] out[23]=A_reg[23] out[22]=A_reg[22]
+ out[21]=A_reg[21] out[20]=A_reg[20] out[19]=A_reg[19] out[18]=A_reg[18]
+ out[17]=A_reg[17] out[16]=A_reg[16] out[15]=A_reg[15] out[14]=A_reg[14]
+ out[13]=A_reg[13] out[12]=A_reg[12] out[11]=A_reg[11] out[10]=A_reg[10]
+ out[9]=A_reg[9] out[8]=A_reg[8] out[7]=A_reg[7] out[6]=A_reg[6] out[5]=A_reg[5]
+ out[4]=A_reg[4] out[3]=A_reg[3] out[2]=A_reg[2] out[1]=A_reg[1] out[0]=A_reg[0]
+ en=en inp[31]=inputA[31] inp[30]=inputA[30] inp[29]=inputA[29]
+ inp[28]=inputA[28] inp[27]=inputA[27] inp[26]=inputA[26] inp[25]=inputA[25]
+ inp[24]=inputA[24] inp[23]=inputA[23] inp[22]=inputA[22] inp[21]=inputA[21]
+ inp[20]=inputA[20] inp[19]=inputA[19] inp[18]=inputA[18] inp[17]=inputA[17]
+ inp[16]=inputA[16] inp[15]=inputA[15] inp[14]=inputA[14] inp[13]=inputA[13]
+ inp[12]=inputA[12] inp[11]=inputA[11] inp[10]=inputA[10] inp[9]=inputA[9]
+ inp[8]=inputA[8] inp[7]=inputA[7] inp[6]=inputA[6] inp[5]=inputA[5]
+ inp[4]=inputA[4] inp[3]=inputA[3] inp[2]=inputA[2] inp[1]=inputA[1]
+ inp[0]=inputA[0] reset=reset clk_CTSPP_2=CLOCK_n33 VDD=VDD VSS=VSS
XCTS_L1_c1_c170 CLKBUF_X3 $PINS Z=CLOCK_n33 A=clk VDD=VDD VSS=VSS
.ENDS
.GLOBAL VDD
.GLOBAL VSS
