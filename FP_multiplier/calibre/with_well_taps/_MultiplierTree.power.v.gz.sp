$ Spice netlist generated by v2lvs
$ v2020.1_25.14    Mon Feb 3 16:40:08 PST 2020
*.BUSDELIMITER [

.SUBCKT registerNbits VDD VSS clk reset en inp[31] inp[30] inp[29] inp[28]
+ inp[27] inp[26] inp[25] inp[24] inp[23] inp[22] inp[21] inp[20] inp[19]
+ inp[18] inp[17] inp[16] inp[15] inp[14] inp[13] inp[12] inp[11] inp[10]
+ inp[9] inp[8] inp[7] inp[6] inp[5] inp[4] inp[3] inp[2] inp[1] inp[0] out[31]
+ out[30] out[29] out[28] out[27] out[26] out[25] out[24] out[23] out[22]
+ out[21] out[20] out[19] out[18] out[17] out[16] out[15] out[14] out[13]
+ out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5] out[4] out[3]
+ out[2] out[1] out[0]
Xi_0_33 AND2_X1 $PINS ZN=n_33 A1=n_0_0 A2=inp[31] VDD=VDD VSS=VSS
Xi_0_32 AND2_X1 $PINS ZN=n_32 A1=n_0_0 A2=inp[30] VDD=VDD VSS=VSS
Xi_0_31 AND2_X1 $PINS ZN=n_31 A1=n_0_0 A2=inp[29] VDD=VDD VSS=VSS
Xi_0_30 AND2_X1 $PINS ZN=n_30 A1=n_0_0 A2=inp[28] VDD=VDD VSS=VSS
Xi_0_29 AND2_X1 $PINS ZN=n_29 A1=n_0_0 A2=inp[27] VDD=VDD VSS=VSS
Xi_0_28 AND2_X1 $PINS ZN=n_28 A1=n_0_0 A2=inp[26] VDD=VDD VSS=VSS
Xi_0_27 AND2_X1 $PINS ZN=n_27 A1=n_0_0 A2=inp[25] VDD=VDD VSS=VSS
Xi_0_26 AND2_X1 $PINS ZN=n_26 A1=n_0_0 A2=inp[24] VDD=VDD VSS=VSS
Xi_0_25 AND2_X1 $PINS ZN=n_25 A1=n_0_0 A2=inp[23] VDD=VDD VSS=VSS
Xi_0_24 AND2_X1 $PINS ZN=n_24 A1=n_0_0 A2=inp[22] VDD=VDD VSS=VSS
Xi_0_23 AND2_X1 $PINS ZN=n_23 A1=n_0_0 A2=inp[21] VDD=VDD VSS=VSS
Xi_0_22 AND2_X1 $PINS ZN=n_22 A1=n_0_0 A2=inp[20] VDD=VDD VSS=VSS
Xi_0_21 AND2_X1 $PINS ZN=n_21 A1=n_0_0 A2=inp[19] VDD=VDD VSS=VSS
Xi_0_20 AND2_X1 $PINS ZN=n_20 A1=n_0_0 A2=inp[18] VDD=VDD VSS=VSS
Xi_0_19 AND2_X1 $PINS ZN=n_19 A1=n_0_0 A2=inp[17] VDD=VDD VSS=VSS
Xi_0_18 AND2_X1 $PINS ZN=n_18 A1=n_0_0 A2=inp[16] VDD=VDD VSS=VSS
Xi_0_17 AND2_X1 $PINS ZN=n_17 A1=n_0_0 A2=inp[15] VDD=VDD VSS=VSS
Xi_0_16 AND2_X1 $PINS ZN=n_16 A1=n_0_0 A2=inp[14] VDD=VDD VSS=VSS
Xi_0_15 AND2_X1 $PINS ZN=n_15 A1=n_0_0 A2=inp[13] VDD=VDD VSS=VSS
Xi_0_14 AND2_X1 $PINS ZN=n_14 A1=n_0_0 A2=inp[12] VDD=VDD VSS=VSS
Xi_0_13 AND2_X1 $PINS ZN=n_13 A1=n_0_0 A2=inp[11] VDD=VDD VSS=VSS
Xi_0_12 AND2_X1 $PINS ZN=n_12 A1=n_0_0 A2=inp[10] VDD=VDD VSS=VSS
Xi_0_11 AND2_X1 $PINS ZN=n_11 A1=n_0_0 A2=inp[9] VDD=VDD VSS=VSS
Xi_0_10 AND2_X1 $PINS ZN=n_10 A1=n_0_0 A2=inp[8] VDD=VDD VSS=VSS
Xi_0_9 AND2_X1 $PINS ZN=n_9 A1=n_0_0 A2=inp[7] VDD=VDD VSS=VSS
Xi_0_8 AND2_X1 $PINS ZN=n_8 A1=n_0_0 A2=inp[6] VDD=VDD VSS=VSS
Xi_0_7 AND2_X1 $PINS ZN=n_7 A1=n_0_0 A2=inp[5] VDD=VDD VSS=VSS
Xi_0_6 AND2_X1 $PINS ZN=n_6 A1=n_0_0 A2=inp[4] VDD=VDD VSS=VSS
Xi_0_5 AND2_X1 $PINS ZN=n_5 A1=n_0_0 A2=inp[3] VDD=VDD VSS=VSS
Xi_0_4 AND2_X1 $PINS ZN=n_4 A1=n_0_0 A2=inp[2] VDD=VDD VSS=VSS
Xi_0_3 AND2_X1 $PINS ZN=n_3 A1=n_0_0 A2=inp[1] VDD=VDD VSS=VSS
Xi_0_2 AND2_X1 $PINS ZN=n_2 A1=n_0_0 A2=inp[0] VDD=VDD VSS=VSS
Xi_0_1 INV_X1 $PINS ZN=n_0_0 A=reset VDD=VDD VSS=VSS
Xi_0_0 OR2_X1 $PINS ZN=n_1 A1=en A2=reset VDD=VDD VSS=VSS
Xout_reg[0] DFF_X1 $PINS Q=out[0] CK=n_0 D=n_2 VDD=VDD VSS=VSS
Xout_reg[1] DFF_X1 $PINS Q=out[1] CK=n_0 D=n_3 VDD=VDD VSS=VSS
Xout_reg[2] DFF_X1 $PINS Q=out[2] CK=n_0 D=n_4 VDD=VDD VSS=VSS
Xout_reg[3] DFF_X1 $PINS Q=out[3] CK=n_0 D=n_5 VDD=VDD VSS=VSS
Xout_reg[4] DFF_X1 $PINS Q=out[4] CK=n_0 D=n_6 VDD=VDD VSS=VSS
Xout_reg[5] DFF_X1 $PINS Q=out[5] CK=n_0 D=n_7 VDD=VDD VSS=VSS
Xout_reg[6] DFF_X1 $PINS Q=out[6] CK=n_0 D=n_8 VDD=VDD VSS=VSS
Xout_reg[7] DFF_X1 $PINS Q=out[7] CK=n_0 D=n_9 VDD=VDD VSS=VSS
Xout_reg[8] DFF_X1 $PINS Q=out[8] CK=n_0 D=n_10 VDD=VDD VSS=VSS
Xout_reg[9] DFF_X1 $PINS Q=out[9] CK=n_0 D=n_11 VDD=VDD VSS=VSS
Xout_reg[10] DFF_X1 $PINS Q=out[10] CK=n_0 D=n_12 VDD=VDD VSS=VSS
Xout_reg[11] DFF_X1 $PINS Q=out[11] CK=n_0 D=n_13 VDD=VDD VSS=VSS
Xout_reg[12] DFF_X1 $PINS Q=out[12] CK=n_0 D=n_14 VDD=VDD VSS=VSS
Xout_reg[13] DFF_X1 $PINS Q=out[13] CK=n_0 D=n_15 VDD=VDD VSS=VSS
Xout_reg[14] DFF_X1 $PINS Q=out[14] CK=n_0 D=n_16 VDD=VDD VSS=VSS
Xout_reg[15] DFF_X1 $PINS Q=out[15] CK=n_0 D=n_17 VDD=VDD VSS=VSS
Xout_reg[16] DFF_X1 $PINS Q=out[16] CK=n_0 D=n_18 VDD=VDD VSS=VSS
Xout_reg[17] DFF_X1 $PINS Q=out[17] CK=n_0 D=n_19 VDD=VDD VSS=VSS
Xout_reg[18] DFF_X1 $PINS Q=out[18] CK=n_0 D=n_20 VDD=VDD VSS=VSS
Xout_reg[19] DFF_X1 $PINS Q=out[19] CK=n_0 D=n_21 VDD=VDD VSS=VSS
Xout_reg[20] DFF_X1 $PINS Q=out[20] CK=n_0 D=n_22 VDD=VDD VSS=VSS
Xout_reg[21] DFF_X1 $PINS Q=out[21] CK=n_0 D=n_23 VDD=VDD VSS=VSS
Xout_reg[22] DFF_X1 $PINS Q=out[22] CK=n_0 D=n_24 VDD=VDD VSS=VSS
Xout_reg[23] DFF_X1 $PINS Q=out[23] CK=n_0 D=n_25 VDD=VDD VSS=VSS
Xout_reg[24] DFF_X1 $PINS Q=out[24] CK=n_0 D=n_26 VDD=VDD VSS=VSS
Xout_reg[25] DFF_X1 $PINS Q=out[25] CK=n_0 D=n_27 VDD=VDD VSS=VSS
Xout_reg[26] DFF_X1 $PINS Q=out[26] CK=n_0 D=n_28 VDD=VDD VSS=VSS
Xout_reg[27] DFF_X1 $PINS Q=out[27] CK=n_0 D=n_29 VDD=VDD VSS=VSS
Xout_reg[28] DFF_X1 $PINS Q=out[28] CK=n_0 D=n_30 VDD=VDD VSS=VSS
Xout_reg[29] DFF_X1 $PINS Q=out[29] CK=n_0 D=n_31 VDD=VDD VSS=VSS
Xout_reg[30] DFF_X1 $PINS Q=out[30] CK=n_0 D=n_32 VDD=VDD VSS=VSS
Xout_reg[31] DFF_X1 $PINS Q=out[31] CK=n_0 D=n_33 VDD=VDD VSS=VSS
Xclk_gate_out_reg CLKGATETST_X1 $PINS GCK=n_0 CK=clk E=n_1 SE=VSS VDD=VDD
+ VSS=VSS
.ENDS

.SUBCKT datapath__0_5 VDD VSS p_0[22] p_0[21] p_0[20] p_0[19] p_0[18] p_0[17]
+ p_0[16] p_0[15] p_0[14] p_0[13] p_0[12] p_0[11] p_0[10] p_0[9] p_0[8] p_0[7]
+ p_0[6] p_0[5] p_0[4] p_0[3] p_0[2] p_0[1] p_0[0] p_1[22] p_1[21] p_1[20]
+ p_1[19] p_1[18] p_1[17] p_1[16] p_1[15] p_1[14] p_1[13] p_1[12] p_1[11]
+ p_1[10] p_1[9] p_1[8] p_1[7] p_1[6] p_1[5] p_1[4] p_1[3] p_1[2] p_1[1] p_1[0]
+ O_final_mantessa[22] O_final_mantessa[21] O_final_mantessa[20]
+ O_final_mantessa[19] O_final_mantessa[18] O_final_mantessa[17]
+ O_final_mantessa[16] O_final_mantessa[15] O_final_mantessa[14]
+ O_final_mantessa[13] O_final_mantessa[12] O_final_mantessa[11]
+ O_final_mantessa[10] O_final_mantessa[9] O_final_mantessa[8]
+ O_final_mantessa[7] O_final_mantessa[6] O_final_mantessa[5]
+ O_final_mantessa[4] O_final_mantessa[3] O_final_mantessa[2]
+ O_final_mantessa[1] O_final_mantessa[0]
Xi_22 XOR2_X1 $PINS Z=O_final_mantessa[22] A=p_1[22] B=n_21 VDD=VDD VSS=VSS
Xi_21 HA_X1 $PINS CO=n_21 S=O_final_mantessa[21] A=p_1[21] B=n_20 VDD=VDD
+ VSS=VSS
Xi_20 HA_X1 $PINS CO=n_20 S=O_final_mantessa[20] A=p_1[20] B=n_19 VDD=VDD
+ VSS=VSS
Xi_19 HA_X1 $PINS CO=n_19 S=O_final_mantessa[19] A=p_1[19] B=n_18 VDD=VDD
+ VSS=VSS
Xi_18 HA_X1 $PINS CO=n_18 S=O_final_mantessa[18] A=p_1[18] B=n_17 VDD=VDD
+ VSS=VSS
Xi_17 HA_X1 $PINS CO=n_17 S=O_final_mantessa[17] A=p_1[17] B=n_16 VDD=VDD
+ VSS=VSS
Xi_16 HA_X1 $PINS CO=n_16 S=O_final_mantessa[16] A=p_1[16] B=n_15 VDD=VDD
+ VSS=VSS
Xi_15 HA_X1 $PINS CO=n_15 S=O_final_mantessa[15] A=p_1[15] B=n_14 VDD=VDD
+ VSS=VSS
Xi_14 HA_X1 $PINS CO=n_14 S=O_final_mantessa[14] A=p_1[14] B=n_13 VDD=VDD
+ VSS=VSS
Xi_13 HA_X1 $PINS CO=n_13 S=O_final_mantessa[13] A=p_1[13] B=n_12 VDD=VDD
+ VSS=VSS
Xi_12 HA_X1 $PINS CO=n_12 S=O_final_mantessa[12] A=p_1[12] B=n_11 VDD=VDD
+ VSS=VSS
Xi_11 HA_X1 $PINS CO=n_11 S=O_final_mantessa[11] A=p_1[11] B=n_10 VDD=VDD
+ VSS=VSS
Xi_10 HA_X1 $PINS CO=n_10 S=O_final_mantessa[10] A=p_1[10] B=n_9 VDD=VDD
+ VSS=VSS
Xi_9 HA_X1 $PINS CO=n_9 S=O_final_mantessa[9] A=p_1[9] B=n_8 VDD=VDD VSS=VSS
Xi_8 HA_X1 $PINS CO=n_8 S=O_final_mantessa[8] A=p_1[8] B=n_7 VDD=VDD VSS=VSS
Xi_7 HA_X1 $PINS CO=n_7 S=O_final_mantessa[7] A=p_1[7] B=n_6 VDD=VDD VSS=VSS
Xi_6 HA_X1 $PINS CO=n_6 S=O_final_mantessa[6] A=p_1[6] B=n_5 VDD=VDD VSS=VSS
Xi_5 HA_X1 $PINS CO=n_5 S=O_final_mantessa[5] A=p_1[5] B=n_4 VDD=VDD VSS=VSS
Xi_4 HA_X1 $PINS CO=n_4 S=O_final_mantessa[4] A=p_1[4] B=n_3 VDD=VDD VSS=VSS
Xi_3 HA_X1 $PINS CO=n_3 S=O_final_mantessa[3] A=p_1[3] B=n_2 VDD=VDD VSS=VSS
Xi_2 HA_X1 $PINS CO=n_2 S=O_final_mantessa[2] A=p_1[2] B=n_1 VDD=VDD VSS=VSS
Xi_1 HA_X1 $PINS CO=n_1 S=O_final_mantessa[1] A=p_1[1] B=n_0 VDD=VDD VSS=VSS
Xi_0 HA_X1 $PINS CO=n_0 S=O_final_mantessa[0] A=p_0[0] B=p_1[0] VDD=VDD VSS=VSS
.ENDS

.SUBCKT datapath VDD VSS b_mantissa[23] b_mantissa[22] b_mantissa[21]
+ b_mantissa[20] b_mantissa[19] b_mantissa[18] b_mantissa[17] b_mantissa[16]
+ b_mantissa[15] b_mantissa[14] b_mantissa[13] b_mantissa[12] b_mantissa[11]
+ b_mantissa[10] b_mantissa[9] b_mantissa[8] b_mantissa[7] b_mantissa[6]
+ b_mantissa[5] b_mantissa[4] b_mantissa[3] b_mantissa[2] b_mantissa[1]
+ b_mantissa[0] a_mantissa[23] a_mantissa[22] a_mantissa[21] a_mantissa[20]
+ a_mantissa[19] a_mantissa[18] a_mantissa[17] a_mantissa[16] a_mantissa[15]
+ a_mantissa[14] a_mantissa[13] a_mantissa[12] a_mantissa[11] a_mantissa[10]
+ a_mantissa[9] a_mantissa[8] a_mantissa[7] a_mantissa[6] a_mantissa[5]
+ a_mantissa[4] a_mantissa[3] a_mantissa[2] a_mantissa[1] a_mantissa[0]
+ o_mantissa[47] o_mantissa[46] o_mantissa[45] o_mantissa[44] o_mantissa[43]
+ o_mantissa[42] o_mantissa[41] o_mantissa[40] o_mantissa[39] o_mantissa[38]
+ o_mantissa[37] o_mantissa[36] o_mantissa[35] o_mantissa[34] o_mantissa[33]
+ o_mantissa[32] o_mantissa[31] o_mantissa[30] o_mantissa[29] o_mantissa[28]
+ o_mantissa[27] o_mantissa[26] o_mantissa[25] o_mantissa[24] o_mantissa[23]
+ o_mantissa[22] o_mantissa[21] o_mantissa[20] o_mantissa[19] o_mantissa[18]
+ o_mantissa[17] o_mantissa[16] o_mantissa[15] o_mantissa[14] o_mantissa[13]
+ o_mantissa[12] o_mantissa[11] o_mantissa[10] o_mantissa[9] o_mantissa[8]
+ o_mantissa[7] o_mantissa[6] o_mantissa[5] o_mantissa[4] o_mantissa[3]
+ o_mantissa[2] o_mantissa[1] o_mantissa[0]
Xi_1381 INV_X2 $PINS ZN=n_1839 A=b_mantissa[22] VDD=VDD VSS=VSS
Xi_1380 INV_X2 $PINS ZN=n_1838 A=b_mantissa[21] VDD=VDD VSS=VSS
Xi_1379 INV_X2 $PINS ZN=n_1837 A=b_mantissa[20] VDD=VDD VSS=VSS
Xi_1378 INV_X2 $PINS ZN=n_1836 A=b_mantissa[19] VDD=VDD VSS=VSS
Xi_1377 INV_X2 $PINS ZN=n_1835 A=b_mantissa[18] VDD=VDD VSS=VSS
Xi_1376 INV_X2 $PINS ZN=n_1834 A=b_mantissa[17] VDD=VDD VSS=VSS
Xi_1375 INV_X2 $PINS ZN=n_1833 A=b_mantissa[16] VDD=VDD VSS=VSS
Xi_1374 INV_X2 $PINS ZN=n_1832 A=b_mantissa[15] VDD=VDD VSS=VSS
Xi_1373 INV_X2 $PINS ZN=n_1831 A=b_mantissa[14] VDD=VDD VSS=VSS
Xi_1372 INV_X2 $PINS ZN=n_1830 A=b_mantissa[13] VDD=VDD VSS=VSS
Xi_1371 INV_X2 $PINS ZN=n_1829 A=b_mantissa[12] VDD=VDD VSS=VSS
Xi_1370 INV_X2 $PINS ZN=n_1828 A=b_mantissa[11] VDD=VDD VSS=VSS
Xi_1369 INV_X2 $PINS ZN=n_1827 A=b_mantissa[10] VDD=VDD VSS=VSS
Xi_1368 INV_X2 $PINS ZN=n_1826 A=b_mantissa[9] VDD=VDD VSS=VSS
Xi_1367 INV_X2 $PINS ZN=n_1825 A=b_mantissa[8] VDD=VDD VSS=VSS
Xi_1366 INV_X2 $PINS ZN=n_1824 A=b_mantissa[7] VDD=VDD VSS=VSS
Xi_1365 INV_X2 $PINS ZN=n_1823 A=b_mantissa[6] VDD=VDD VSS=VSS
Xi_1364 INV_X2 $PINS ZN=n_1822 A=b_mantissa[5] VDD=VDD VSS=VSS
Xi_1363 INV_X2 $PINS ZN=n_1821 A=b_mantissa[4] VDD=VDD VSS=VSS
Xi_1362 INV_X2 $PINS ZN=n_1820 A=b_mantissa[3] VDD=VDD VSS=VSS
Xi_1361 INV_X2 $PINS ZN=n_1819 A=b_mantissa[2] VDD=VDD VSS=VSS
Xi_1360 INV_X2 $PINS ZN=n_1818 A=b_mantissa[1] VDD=VDD VSS=VSS
Xi_1359 INV_X2 $PINS ZN=n_1817 A=b_mantissa[0] VDD=VDD VSS=VSS
Xi_1358 INV_X1 $PINS ZN=n_1816 A=a_mantissa[22] VDD=VDD VSS=VSS
Xi_1357 INV_X2 $PINS ZN=n_1815 A=a_mantissa[21] VDD=VDD VSS=VSS
Xi_1356 INV_X2 $PINS ZN=n_1814 A=a_mantissa[20] VDD=VDD VSS=VSS
Xi_1355 INV_X2 $PINS ZN=n_1813 A=a_mantissa[19] VDD=VDD VSS=VSS
Xi_1354 INV_X2 $PINS ZN=n_1812 A=a_mantissa[18] VDD=VDD VSS=VSS
Xi_1353 INV_X2 $PINS ZN=n_1811 A=a_mantissa[17] VDD=VDD VSS=VSS
Xi_1352 INV_X2 $PINS ZN=n_1810 A=a_mantissa[16] VDD=VDD VSS=VSS
Xi_1351 INV_X2 $PINS ZN=n_1809 A=a_mantissa[15] VDD=VDD VSS=VSS
Xi_1350 INV_X2 $PINS ZN=n_1808 A=a_mantissa[14] VDD=VDD VSS=VSS
Xi_1349 INV_X2 $PINS ZN=n_1807 A=a_mantissa[13] VDD=VDD VSS=VSS
Xi_1348 INV_X2 $PINS ZN=n_1806 A=a_mantissa[12] VDD=VDD VSS=VSS
Xi_1347 INV_X2 $PINS ZN=n_1805 A=a_mantissa[11] VDD=VDD VSS=VSS
Xi_1346 INV_X2 $PINS ZN=n_1804 A=a_mantissa[10] VDD=VDD VSS=VSS
Xi_1345 INV_X2 $PINS ZN=n_1803 A=a_mantissa[9] VDD=VDD VSS=VSS
Xi_1344 INV_X2 $PINS ZN=n_1802 A=a_mantissa[8] VDD=VDD VSS=VSS
Xi_1343 INV_X2 $PINS ZN=n_1801 A=a_mantissa[7] VDD=VDD VSS=VSS
Xi_1342 INV_X2 $PINS ZN=n_1800 A=a_mantissa[6] VDD=VDD VSS=VSS
Xi_1341 INV_X2 $PINS ZN=n_1799 A=a_mantissa[5] VDD=VDD VSS=VSS
Xi_1340 INV_X2 $PINS ZN=n_1798 A=a_mantissa[4] VDD=VDD VSS=VSS
Xi_1339 INV_X1 $PINS ZN=n_1797 A=a_mantissa[3] VDD=VDD VSS=VSS
Xi_1338 INV_X2 $PINS ZN=n_1796 A=a_mantissa[2] VDD=VDD VSS=VSS
Xi_1337 INV_X2 $PINS ZN=n_1795 A=a_mantissa[1] VDD=VDD VSS=VSS
Xi_1336 INV_X1 $PINS ZN=n_1794 A=a_mantissa[0] VDD=VDD VSS=VSS
Xi_1335 NAND2_X1 $PINS ZN=n_1793 A1=n_1009 A2=n_1010 VDD=VDD VSS=VSS
Xi_1334 NOR2_X1 $PINS ZN=n_1792 A1=n_1009 A2=n_1010 VDD=VDD VSS=VSS
Xi_1333 AND2_X1 $PINS ZN=n_1791 A1=n_6 A2=n_10 VDD=VDD VSS=VSS
Xi_1332 NAND2_X1 $PINS ZN=n_1790 A1=n_2 A2=n_4 VDD=VDD VSS=VSS
Xi_1331 NOR2_X1 $PINS ZN=n_1789 A1=n_1817 A2=n_1796 VDD=VDD VSS=VSS
Xi_1330 NOR2_X1 $PINS ZN=n_1788 A1=n_0 A2=n_1789 VDD=VDD VSS=VSS
Xi_1329 NOR2_X1 $PINS ZN=n_1787 A1=n_1818 A2=n_1794 VDD=VDD VSS=VSS
Xi_1328 NOR2_X1 $PINS ZN=n_1786 A1=n_1817 A2=n_1795 VDD=VDD VSS=VSS
Xi_1327 NOR2_X1 $PINS ZN=o_mantissa[0] A1=n_1817 A2=n_1794 VDD=VDD VSS=VSS
Xi_1326 NOR2_X1 $PINS ZN=n_1785 A1=n_1818 A2=n_1795 VDD=VDD VSS=VSS
Xi_1325 NAND2_X1 $PINS ZN=n_1784 A1=o_mantissa[0] A2=n_1785 VDD=VDD VSS=VSS
Xi_1324 NAND2_X1 $PINS ZN=n_1783 A1=n_0 A2=n_1789 VDD=VDD VSS=VSS
Xi_1323 AOI21_X1 $PINS ZN=n_1782 A=n_1788 B1=n_1784 B2=n_1783 VDD=VDD VSS=VSS
Xi_1322 OAI21_X1 $PINS ZN=n_1781 A=n_1782 B1=n_2 B2=n_4 VDD=VDD VSS=VSS
Xi_1321 NAND2_X1 $PINS ZN=n_1780 A1=n_1790 A2=n_1781 VDD=VDD VSS=VSS
Xi_1320 OAI22_X1 $PINS ZN=n_1779 A1=n_6 A2=n_10 B1=n_1791 B2=n_1780 VDD=VDD
+ VSS=VSS
Xi_1319 NOR2_X1 $PINS ZN=n_1778 A1=n_52 A2=n_54 VDD=VDD VSS=VSS
Xi_1318 NOR2_X1 $PINS ZN=n_1777 A1=n_26 A2=n_28 VDD=VDD VSS=VSS
Xi_1317 NOR2_X1 $PINS ZN=n_1776 A1=n_38 A2=n_40 VDD=VDD VSS=VSS
Xi_1316 OR3_X1 $PINS ZN=n_1775 A1=n_1778 A2=n_1776 A3=n_1777 VDD=VDD VSS=VSS
Xi_1315 NOR2_X1 $PINS ZN=n_1774 A1=n_16 A2=n_18 VDD=VDD VSS=VSS
Xi_1314 NOR3_X1 $PINS ZN=n_1773 A1=n_1775 A2=n_1774 A3=n_1779 VDD=VDD VSS=VSS
Xi_1313 NAND2_X1 $PINS ZN=n_1772 A1=n_16 A2=n_18 VDD=VDD VSS=VSS
Xi_1312 NAND2_X1 $PINS ZN=n_1771 A1=n_26 A2=n_28 VDD=VDD VSS=VSS
Xi_1311 AOI21_X1 $PINS ZN=n_1770 A=n_1775 B1=n_1772 B2=n_1771 VDD=VDD VSS=VSS
Xi_1310 AND2_X1 $PINS ZN=n_1769 A1=n_52 A2=n_54 VDD=VDD VSS=VSS
Xi_1309 NAND2_X1 $PINS ZN=n_1768 A1=n_38 A2=n_40 VDD=VDD VSS=VSS
Xi_1308 INV_X1 $PINS ZN=n_1767 A=n_1768 VDD=VDD VSS=VSS
Xi_1307 NOR2_X1 $PINS ZN=n_1766 A1=n_1778 A2=n_1768 VDD=VDD VSS=VSS
Xi_1306 NOR4_X1 $PINS ZN=n_1765 A1=n_1769 A2=n_1766 A3=n_1770 A4=n_1773 VDD=VDD
+ VSS=VSS
Xi_1305 NOR2_X1 $PINS ZN=n_1764 A1=n_128 A2=n_130 VDD=VDD VSS=VSS
Xi_1304 NOR2_X1 $PINS ZN=n_1763 A1=n_86 A2=n_88 VDD=VDD VSS=VSS
Xi_1303 NOR2_X1 $PINS ZN=n_1762 A1=n_106 A2=n_108 VDD=VDD VSS=VSS
Xi_1302 OR3_X1 $PINS ZN=n_1761 A1=n_1764 A2=n_1762 A3=n_1763 VDD=VDD VSS=VSS
Xi_1301 NOR2_X1 $PINS ZN=n_1760 A1=n_68 A2=n_70 VDD=VDD VSS=VSS
Xi_1300 NOR3_X1 $PINS ZN=n_1759 A1=n_1761 A2=n_1760 A3=n_1765 VDD=VDD VSS=VSS
Xi_1299 NAND2_X1 $PINS ZN=n_1758 A1=n_68 A2=n_70 VDD=VDD VSS=VSS
Xi_1298 NAND2_X1 $PINS ZN=n_1757 A1=n_86 A2=n_88 VDD=VDD VSS=VSS
Xi_1297 AOI21_X1 $PINS ZN=n_1756 A=n_1761 B1=n_1758 B2=n_1757 VDD=VDD VSS=VSS
Xi_1296 AND2_X1 $PINS ZN=n_1755 A1=n_128 A2=n_130 VDD=VDD VSS=VSS
Xi_1295 NAND2_X1 $PINS ZN=n_1754 A1=n_106 A2=n_108 VDD=VDD VSS=VSS
Xi_1294 INV_X1 $PINS ZN=n_1753 A=n_1754 VDD=VDD VSS=VSS
Xi_1293 NOR2_X1 $PINS ZN=n_1752 A1=n_1764 A2=n_1754 VDD=VDD VSS=VSS
Xi_1292 NOR4_X1 $PINS ZN=n_1751 A1=n_1755 A2=n_1752 A3=n_1756 A4=n_1759 VDD=VDD
+ VSS=VSS
Xi_1291 NOR2_X1 $PINS ZN=n_1750 A1=n_236 A2=n_238 VDD=VDD VSS=VSS
Xi_1290 NOR2_X1 $PINS ZN=n_1749 A1=n_178 A2=n_180 VDD=VDD VSS=VSS
Xi_1289 NOR2_X1 $PINS ZN=n_1748 A1=n_206 A2=n_208 VDD=VDD VSS=VSS
Xi_1288 OR3_X1 $PINS ZN=n_1747 A1=n_1750 A2=n_1748 A3=n_1749 VDD=VDD VSS=VSS
Xi_1287 NOR2_X1 $PINS ZN=n_1746 A1=n_152 A2=n_154 VDD=VDD VSS=VSS
Xi_1286 NOR3_X1 $PINS ZN=n_1745 A1=n_1747 A2=n_1746 A3=n_1751 VDD=VDD VSS=VSS
Xi_1285 NAND2_X1 $PINS ZN=n_1744 A1=n_152 A2=n_154 VDD=VDD VSS=VSS
Xi_1284 NAND2_X1 $PINS ZN=n_1743 A1=n_178 A2=n_180 VDD=VDD VSS=VSS
Xi_1283 AOI21_X1 $PINS ZN=n_1742 A=n_1747 B1=n_1744 B2=n_1743 VDD=VDD VSS=VSS
Xi_1282 AND2_X1 $PINS ZN=n_1741 A1=n_236 A2=n_238 VDD=VDD VSS=VSS
Xi_1281 NAND2_X1 $PINS ZN=n_1740 A1=n_206 A2=n_208 VDD=VDD VSS=VSS
Xi_1280 INV_X1 $PINS ZN=n_1739 A=n_1740 VDD=VDD VSS=VSS
Xi_1279 NOR2_X1 $PINS ZN=n_1738 A1=n_1750 A2=n_1740 VDD=VDD VSS=VSS
Xi_1278 NOR4_X4 $PINS ZN=n_1737 A1=n_1741 A2=n_1738 A3=n_1742 A4=n_1745 VDD=VDD
+ VSS=VSS
Xi_1277 NOR2_X1 $PINS ZN=n_1736 A1=n_379 A2=n_418 VDD=VDD VSS=VSS
Xi_1276 NOR2_X1 $PINS ZN=n_1735 A1=n_505 A2=n_548 VDD=VDD VSS=VSS
Xi_1275 INV_X1 $PINS ZN=n_1734 A=n_1735 VDD=VDD VSS=VSS
Xi_1274 NOR2_X1 $PINS ZN=n_1733 A1=n_419 A2=n_460 VDD=VDD VSS=VSS
Xi_1273 INV_X1 $PINS ZN=n_1732 A=n_1733 VDD=VDD VSS=VSS
Xi_1272 NOR2_X1 $PINS ZN=n_1731 A1=n_461 A2=n_504 VDD=VDD VSS=VSS
Xi_1271 INV_X1 $PINS ZN=n_1730 A=n_1731 VDD=VDD VSS=VSS
Xi_1270 NAND3_X1 $PINS ZN=n_1729 A1=n_1734 A2=n_1730 A3=n_1732 VDD=VDD VSS=VSS
Xi_1269 OR2_X1 $PINS ZN=n_1728 A1=n_1736 A2=n_1729 VDD=VDD VSS=VSS
Xi_1268 NOR2_X1 $PINS ZN=n_1727 A1=n_801 A2=n_828 VDD=VDD VSS=VSS
Xi_1267 NOR2_X1 $PINS ZN=n_1726 A1=n_739 A2=n_770 VDD=VDD VSS=VSS
Xi_1266 NOR2_X1 $PINS ZN=n_1725 A1=n_771 A2=n_800 VDD=VDD VSS=VSS
Xi_1265 NOR2_X1 $PINS ZN=n_1724 A1=n_1726 A2=n_1725 VDD=VDD VSS=VSS
Xi_1264 NOR3_X1 $PINS ZN=n_1723 A1=n_1727 A2=n_1725 A3=n_1726 VDD=VDD VSS=VSS
Xi_1263 OAI21_X1 $PINS ZN=n_1722 A=n_1723 B1=n_705 B2=n_738 VDD=VDD VSS=VSS
Xi_1262 NOR2_X1 $PINS ZN=n_1721 A1=n_669 A2=n_704 VDD=VDD VSS=VSS
Xi_1261 INV_X1 $PINS ZN=n_1720 A=n_1721 VDD=VDD VSS=VSS
Xi_1260 NOR2_X1 $PINS ZN=n_1719 A1=n_591 A2=n_630 VDD=VDD VSS=VSS
Xi_1259 INV_X1 $PINS ZN=n_1718 A=n_1719 VDD=VDD VSS=VSS
Xi_1258 NOR2_X1 $PINS ZN=n_1717 A1=n_631 A2=n_668 VDD=VDD VSS=VSS
Xi_1257 INV_X1 $PINS ZN=n_1716 A=n_1717 VDD=VDD VSS=VSS
Xi_1256 NAND3_X1 $PINS ZN=n_1715 A1=n_1720 A2=n_1716 A3=n_1718 VDD=VDD VSS=VSS
Xi_1255 NOR2_X1 $PINS ZN=n_1714 A1=n_549 A2=n_590 VDD=VDD VSS=VSS
Xi_1254 OR2_X1 $PINS ZN=n_1713 A1=n_1715 A2=n_1714 VDD=VDD VSS=VSS
Xi_1253 OR2_X1 $PINS ZN=n_1712 A1=n_1722 A2=n_1713 VDD=VDD VSS=VSS
Xi_1252 OR2_X1 $PINS ZN=n_1711 A1=n_1728 A2=n_1712 VDD=VDD VSS=VSS
Xi_1251 NOR2_X1 $PINS ZN=n_1710 A1=n_376 A2=n_378 VDD=VDD VSS=VSS
Xi_1250 INV_X1 $PINS ZN=n_1709 A=n_1710 VDD=VDD VSS=VSS
Xi_1249 NOR2_X1 $PINS ZN=n_1708 A1=n_271 A2=n_304 VDD=VDD VSS=VSS
Xi_1248 INV_X1 $PINS ZN=n_1707 A=n_1708 VDD=VDD VSS=VSS
Xi_1247 NOR2_X1 $PINS ZN=n_1706 A1=n_305 A2=n_340 VDD=VDD VSS=VSS
Xi_1246 INV_X1 $PINS ZN=n_1705 A=n_1706 VDD=VDD VSS=VSS
Xi_1245 NAND3_X1 $PINS ZN=n_1704 A1=n_1709 A2=n_1705 A3=n_1707 VDD=VDD VSS=VSS
Xi_1244 NOR2_X1 $PINS ZN=n_1703 A1=n_268 A2=n_270 VDD=VDD VSS=VSS
Xi_1243 OR2_X1 $PINS ZN=n_1702 A1=n_1704 A2=n_1703 VDD=VDD VSS=VSS
Xi_1242 NOR3_X1 $PINS ZN=n_1701 A1=n_1711 A2=n_1702 A3=n_1737 VDD=VDD VSS=VSS
Xi_1241 NAND2_X1 $PINS ZN=n_1700 A1=n_268 A2=n_270 VDD=VDD VSS=VSS
Xi_1240 NAND2_X1 $PINS ZN=n_1699 A1=n_271 A2=n_304 VDD=VDD VSS=VSS
Xi_1239 INV_X1 $PINS ZN=n_1698 A=n_1699 VDD=VDD VSS=VSS
Xi_1238 AOI21_X1 $PINS ZN=n_1697 A=n_1704 B1=n_1700 B2=n_1699 VDD=VDD VSS=VSS
Xi_1237 AND2_X1 $PINS ZN=n_1696 A1=n_305 A2=n_340 VDD=VDD VSS=VSS
Xi_1236 AOI221_X2 $PINS ZN=n_1695 A=n_1697 B1=n_376 B2=n_378 C1=n_1709
+ C2=n_1696 VDD=VDD VSS=VSS
Xi_1235 NOR2_X1 $PINS ZN=n_1694 A1=n_1711 A2=n_1695 VDD=VDD VSS=VSS
Xi_1234 NAND2_X1 $PINS ZN=n_1693 A1=n_379 A2=n_418 VDD=VDD VSS=VSS
Xi_1233 NAND2_X1 $PINS ZN=n_1692 A1=n_419 A2=n_460 VDD=VDD VSS=VSS
Xi_1232 INV_X1 $PINS ZN=n_1691 A=n_1692 VDD=VDD VSS=VSS
Xi_1231 AOI21_X1 $PINS ZN=n_1690 A=n_1729 B1=n_1693 B2=n_1692 VDD=VDD VSS=VSS
Xi_1230 AND2_X1 $PINS ZN=n_1689 A1=n_461 A2=n_504 VDD=VDD VSS=VSS
Xi_1229 AOI221_X1 $PINS ZN=n_1688 A=n_1690 B1=n_505 B2=n_548 C1=n_1734
+ C2=n_1689 VDD=VDD VSS=VSS
Xi_1228 NAND2_X1 $PINS ZN=n_1687 A1=n_705 A2=n_738 VDD=VDD VSS=VSS
Xi_1227 INV_X1 $PINS ZN=n_1686 A=n_1687 VDD=VDD VSS=VSS
Xi_1226 AND2_X1 $PINS ZN=n_1685 A1=n_739 A2=n_770 VDD=VDD VSS=VSS
Xi_1225 OAI21_X1 $PINS ZN=n_1684 A=n_1723 B1=n_1686 B2=n_1685 VDD=VDD VSS=VSS
Xi_1224 NAND2_X1 $PINS ZN=n_1683 A1=n_771 A2=n_800 VDD=VDD VSS=VSS
Xi_1223 INV_X1 $PINS ZN=n_1682 A=n_1683 VDD=VDD VSS=VSS
Xi_1222 OAI21_X1 $PINS ZN=n_1681 A=n_1684 B1=n_1727 B2=n_1683 VDD=VDD VSS=VSS
Xi_1221 AOI21_X1 $PINS ZN=n_1680 A=n_1681 B1=n_801 B2=n_828 VDD=VDD VSS=VSS
Xi_1220 NAND2_X1 $PINS ZN=n_1679 A1=n_549 A2=n_590 VDD=VDD VSS=VSS
Xi_1219 NAND2_X1 $PINS ZN=n_1678 A1=n_591 A2=n_630 VDD=VDD VSS=VSS
Xi_1218 INV_X1 $PINS ZN=n_1677 A=n_1678 VDD=VDD VSS=VSS
Xi_1217 AOI21_X1 $PINS ZN=n_1676 A=n_1715 B1=n_1679 B2=n_1678 VDD=VDD VSS=VSS
Xi_1216 AND2_X1 $PINS ZN=n_1675 A1=n_631 A2=n_668 VDD=VDD VSS=VSS
Xi_1215 AOI221_X1 $PINS ZN=n_1674 A=n_1676 B1=n_669 B2=n_704 C1=n_1720
+ C2=n_1675 VDD=VDD VSS=VSS
Xi_1214 OAI221_X1 $PINS ZN=n_1673 A=n_1680 B1=n_1722 B2=n_1674 C1=n_1712
+ C2=n_1688 VDD=VDD VSS=VSS
Xi_1213 NOR3_X2 $PINS ZN=n_1672 A1=n_1694 A2=n_1673 A3=n_1701 VDD=VDD VSS=VSS
Xi_1212 NOR2_X1 $PINS ZN=n_1671 A1=n_901 A2=n_920 VDD=VDD VSS=VSS
Xi_1211 NOR2_X1 $PINS ZN=n_1670 A1=n_855 A2=n_878 VDD=VDD VSS=VSS
Xi_1210 NOR2_X1 $PINS ZN=n_1669 A1=n_879 A2=n_900 VDD=VDD VSS=VSS
Xi_1209 OR3_X1 $PINS ZN=n_1668 A1=n_1671 A2=n_1669 A3=n_1670 VDD=VDD VSS=VSS
Xi_1208 NOR2_X1 $PINS ZN=n_1667 A1=n_829 A2=n_854 VDD=VDD VSS=VSS
Xi_1207 NOR3_X1 $PINS ZN=n_1666 A1=n_1668 A2=n_1667 A3=n_1672 VDD=VDD VSS=VSS
Xi_1206 NAND2_X1 $PINS ZN=n_1665 A1=n_829 A2=n_854 VDD=VDD VSS=VSS
Xi_1205 NAND2_X1 $PINS ZN=n_1664 A1=n_855 A2=n_878 VDD=VDD VSS=VSS
Xi_1204 AOI21_X1 $PINS ZN=n_1663 A=n_1668 B1=n_1665 B2=n_1664 VDD=VDD VSS=VSS
Xi_1203 AND2_X1 $PINS ZN=n_1662 A1=n_901 A2=n_920 VDD=VDD VSS=VSS
Xi_1202 NAND2_X1 $PINS ZN=n_1661 A1=n_879 A2=n_900 VDD=VDD VSS=VSS
Xi_1201 INV_X1 $PINS ZN=n_1660 A=n_1661 VDD=VDD VSS=VSS
Xi_1200 NOR2_X1 $PINS ZN=n_1659 A1=n_1671 A2=n_1661 VDD=VDD VSS=VSS
Xi_1199 NOR4_X1 $PINS ZN=n_1658 A1=n_1662 A2=n_1659 A3=n_1663 A4=n_1666 VDD=VDD
+ VSS=VSS
Xi_1198 NOR2_X1 $PINS ZN=n_1657 A1=n_969 A2=n_980 VDD=VDD VSS=VSS
Xi_1197 NOR2_X1 $PINS ZN=n_1656 A1=n_939 A2=n_954 VDD=VDD VSS=VSS
Xi_1196 NOR2_X1 $PINS ZN=n_1655 A1=n_955 A2=n_968 VDD=VDD VSS=VSS
Xi_1195 OR3_X1 $PINS ZN=n_1654 A1=n_1657 A2=n_1655 A3=n_1656 VDD=VDD VSS=VSS
Xi_1194 NOR2_X1 $PINS ZN=n_1653 A1=n_921 A2=n_938 VDD=VDD VSS=VSS
Xi_1193 NOR3_X1 $PINS ZN=n_1652 A1=n_1654 A2=n_1653 A3=n_1658 VDD=VDD VSS=VSS
Xi_1192 NAND2_X1 $PINS ZN=n_1651 A1=n_921 A2=n_938 VDD=VDD VSS=VSS
Xi_1191 NAND2_X1 $PINS ZN=n_1650 A1=n_939 A2=n_954 VDD=VDD VSS=VSS
Xi_1190 AOI21_X1 $PINS ZN=n_1649 A=n_1654 B1=n_1651 B2=n_1650 VDD=VDD VSS=VSS
Xi_1189 AND2_X1 $PINS ZN=n_1648 A1=n_969 A2=n_980 VDD=VDD VSS=VSS
Xi_1188 NAND2_X1 $PINS ZN=n_1647 A1=n_955 A2=n_968 VDD=VDD VSS=VSS
Xi_1187 INV_X1 $PINS ZN=n_1646 A=n_1647 VDD=VDD VSS=VSS
Xi_1186 NOR2_X1 $PINS ZN=n_1645 A1=n_1657 A2=n_1647 VDD=VDD VSS=VSS
Xi_1185 NOR4_X1 $PINS ZN=n_1644 A1=n_1648 A2=n_1645 A3=n_1649 A4=n_1652 VDD=VDD
+ VSS=VSS
Xi_1184 NOR2_X1 $PINS ZN=n_1643 A1=n_1005 A2=n_1008 VDD=VDD VSS=VSS
Xi_1183 NOR2_X1 $PINS ZN=n_1642 A1=n_991 A2=n_998 VDD=VDD VSS=VSS
Xi_1182 NOR2_X1 $PINS ZN=n_1641 A1=n_999 A2=n_1004 VDD=VDD VSS=VSS
Xi_1181 NOR2_X1 $PINS ZN=n_1640 A1=n_1642 A2=n_1641 VDD=VDD VSS=VSS
Xi_1180 OAI21_X1 $PINS ZN=n_1639 A=n_1640 B1=n_1005 B2=n_1008 VDD=VDD VSS=VSS
Xi_1179 NOR2_X1 $PINS ZN=n_1638 A1=n_981 A2=n_990 VDD=VDD VSS=VSS
Xi_1178 NOR3_X1 $PINS ZN=n_1637 A1=n_1639 A2=n_1638 A3=n_1644 VDD=VDD VSS=VSS
Xi_1177 NAND2_X1 $PINS ZN=n_1636 A1=n_981 A2=n_990 VDD=VDD VSS=VSS
Xi_1176 NAND2_X1 $PINS ZN=n_1635 A1=n_991 A2=n_998 VDD=VDD VSS=VSS
Xi_1175 INV_X1 $PINS ZN=n_1634 A=n_1635 VDD=VDD VSS=VSS
Xi_1174 AOI21_X1 $PINS ZN=n_1633 A=n_1639 B1=n_1636 B2=n_1635 VDD=VDD VSS=VSS
Xi_1173 AND2_X1 $PINS ZN=n_1632 A1=n_1005 A2=n_1008 VDD=VDD VSS=VSS
Xi_1172 NAND2_X1 $PINS ZN=n_1631 A1=n_999 A2=n_1004 VDD=VDD VSS=VSS
Xi_1171 INV_X1 $PINS ZN=n_1630 A=n_1631 VDD=VDD VSS=VSS
Xi_1170 NOR2_X1 $PINS ZN=n_1629 A1=n_1643 A2=n_1631 VDD=VDD VSS=VSS
Xi_1169 NOR4_X1 $PINS ZN=n_1628 A1=n_1632 A2=n_1629 A3=n_1633 A4=n_1637 VDD=VDD
+ VSS=VSS
Xi_1168 OAI21_X1 $PINS ZN=n_1627 A=n_1793 B1=n_1792 B2=n_1628 VDD=VDD VSS=VSS
Xi_1167 OR2_X2 $PINS ZN=o_mantissa[47] A1=n_1011 A2=n_1627 VDD=VDD VSS=VSS
Xi_1166 XNOR2_X1 $PINS ZN=o_mantissa[46] A=n_1011 B=n_1627 VDD=VDD VSS=VSS
Xi_1165 AOI21_X1 $PINS ZN=n_1626 A=n_1792 B1=n_1009 B2=n_1010 VDD=VDD VSS=VSS
Xi_1164 XNOR2_X1 $PINS ZN=o_mantissa[45] A=n_1628 B=n_1626 VDD=VDD VSS=VSS
Xi_1163 NOR2_X1 $PINS ZN=n_1625 A1=n_1643 A2=n_1632 VDD=VDD VSS=VSS
Xi_1162 OAI21_X1 $PINS ZN=n_1624 A=n_1636 B1=n_981 B2=n_990 VDD=VDD VSS=VSS
Xi_1161 AOI21_X1 $PINS ZN=n_1623 A=n_1638 B1=n_1644 B2=n_1636 VDD=VDD VSS=VSS
Xi_1160 NOR2_X1 $PINS ZN=n_1622 A1=n_1642 A2=n_1634 VDD=VDD VSS=VSS
Xi_1159 NAND2_X1 $PINS ZN=n_1621 A1=n_1631 A2=n_1622 VDD=VDD VSS=VSS
Xi_1158 OAI22_X1 $PINS ZN=n_1620 A1=n_1623 A2=n_1621 B1=n_1640 B2=n_1630
+ VDD=VDD VSS=VSS
Xi_1157 XNOR2_X1 $PINS ZN=o_mantissa[44] A=n_1625 B=n_1620 VDD=VDD VSS=VSS
Xi_1156 NOR2_X1 $PINS ZN=n_1619 A1=n_1641 A2=n_1630 VDD=VDD VSS=VSS
Xi_1155 OAI22_X1 $PINS ZN=n_1618 A1=n_991 A2=n_998 B1=n_1634 B2=n_1623 VDD=VDD
+ VSS=VSS
Xi_1154 XNOR2_X1 $PINS ZN=o_mantissa[43] A=n_1619 B=n_1618 VDD=VDD VSS=VSS
Xi_1153 XOR2_X1 $PINS Z=o_mantissa[42] A=n_1623 B=n_1622 VDD=VDD VSS=VSS
Xi_1152 XOR2_X1 $PINS Z=o_mantissa[41] A=n_1644 B=n_1624 VDD=VDD VSS=VSS
Xi_1151 NOR2_X1 $PINS ZN=n_1617 A1=n_1657 A2=n_1648 VDD=VDD VSS=VSS
Xi_1150 OAI21_X1 $PINS ZN=n_1616 A=n_1651 B1=n_921 B2=n_938 VDD=VDD VSS=VSS
Xi_1149 AOI21_X1 $PINS ZN=n_1615 A=n_1653 B1=n_1658 B2=n_1651 VDD=VDD VSS=VSS
Xi_1148 INV_X1 $PINS ZN=n_1614 A=n_1615 VDD=VDD VSS=VSS
Xi_1147 AOI21_X1 $PINS ZN=n_1613 A=n_1656 B1=n_1650 B2=n_1614 VDD=VDD VSS=VSS
Xi_1146 AOI21_X1 $PINS ZN=n_1612 A=n_1656 B1=n_939 B2=n_954 VDD=VDD VSS=VSS
Xi_1145 OAI22_X1 $PINS ZN=n_1611 A1=n_955 A2=n_968 B1=n_1646 B2=n_1613 VDD=VDD
+ VSS=VSS
Xi_1144 XNOR2_X1 $PINS ZN=o_mantissa[40] A=n_1617 B=n_1611 VDD=VDD VSS=VSS
Xi_1143 NOR2_X1 $PINS ZN=n_1610 A1=n_1655 A2=n_1646 VDD=VDD VSS=VSS
Xi_1142 XOR2_X1 $PINS Z=o_mantissa[39] A=n_1613 B=n_1610 VDD=VDD VSS=VSS
Xi_1141 XOR2_X1 $PINS Z=o_mantissa[38] A=n_1615 B=n_1612 VDD=VDD VSS=VSS
Xi_1140 XOR2_X1 $PINS Z=o_mantissa[37] A=n_1658 B=n_1616 VDD=VDD VSS=VSS
Xi_1139 NOR2_X1 $PINS ZN=n_1609 A1=n_1671 A2=n_1662 VDD=VDD VSS=VSS
Xi_1138 OAI21_X1 $PINS ZN=n_1608 A=n_1665 B1=n_829 B2=n_854 VDD=VDD VSS=VSS
Xi_1137 AOI21_X1 $PINS ZN=n_1607 A=n_1667 B1=n_1672 B2=n_1665 VDD=VDD VSS=VSS
Xi_1136 INV_X1 $PINS ZN=n_1606 A=n_1607 VDD=VDD VSS=VSS
Xi_1135 AOI21_X1 $PINS ZN=n_1605 A=n_1670 B1=n_1664 B2=n_1606 VDD=VDD VSS=VSS
Xi_1134 AOI21_X1 $PINS ZN=n_1604 A=n_1670 B1=n_855 B2=n_878 VDD=VDD VSS=VSS
Xi_1133 OAI22_X1 $PINS ZN=n_1603 A1=n_879 A2=n_900 B1=n_1660 B2=n_1605 VDD=VDD
+ VSS=VSS
Xi_1132 XNOR2_X1 $PINS ZN=o_mantissa[36] A=n_1609 B=n_1603 VDD=VDD VSS=VSS
Xi_1131 NOR2_X1 $PINS ZN=n_1602 A1=n_1669 A2=n_1660 VDD=VDD VSS=VSS
Xi_1130 XOR2_X1 $PINS Z=o_mantissa[35] A=n_1605 B=n_1602 VDD=VDD VSS=VSS
Xi_1129 XOR2_X1 $PINS Z=o_mantissa[34] A=n_1607 B=n_1604 VDD=VDD VSS=VSS
Xi_1128 XOR2_X1 $PINS Z=o_mantissa[33] A=n_1672 B=n_1608 VDD=VDD VSS=VSS
Xi_1127 AOI21_X1 $PINS ZN=n_1601 A=n_1727 B1=n_801 B2=n_828 VDD=VDD VSS=VSS
Xi_1126 OAI21_X1 $PINS ZN=n_1600 A=n_1695 B1=n_1737 B2=n_1702 VDD=VDD VSS=VSS
Xi_1125 INV_X1 $PINS ZN=n_1599 A=n_1600 VDD=VDD VSS=VSS
Xi_1124 OAI21_X1 $PINS ZN=n_1598 A=n_1688 B1=n_1728 B2=n_1599 VDD=VDD VSS=VSS
Xi_1123 INV_X1 $PINS ZN=n_1597 A=n_1598 VDD=VDD VSS=VSS
Xi_1122 OAI21_X1 $PINS ZN=n_1596 A=n_1674 B1=n_1713 B2=n_1597 VDD=VDD VSS=VSS
Xi_1121 OAI21_X1 $PINS ZN=n_1595 A=n_1687 B1=n_705 B2=n_738 VDD=VDD VSS=VSS
Xi_1120 OAI22_X1 $PINS ZN=n_1594 A1=n_705 A2=n_738 B1=n_1686 B2=n_1596 VDD=VDD
+ VSS=VSS
Xi_1119 INV_X1 $PINS ZN=n_1593 A=n_1594 VDD=VDD VSS=VSS
Xi_1118 NOR2_X1 $PINS ZN=n_1592 A1=n_1726 A2=n_1685 VDD=VDD VSS=VSS
Xi_1117 NAND3_X1 $PINS ZN=n_1591 A1=n_1683 A2=n_1592 A3=n_1594 VDD=VDD VSS=VSS
Xi_1116 OAI21_X1 $PINS ZN=n_1590 A=n_1591 B1=n_1724 B2=n_1682 VDD=VDD VSS=VSS
Xi_1115 XNOR2_X1 $PINS ZN=o_mantissa[32] A=n_1601 B=n_1590 VDD=VDD VSS=VSS
Xi_1114 NOR2_X1 $PINS ZN=n_1589 A1=n_1725 A2=n_1682 VDD=VDD VSS=VSS
Xi_1113 OAI22_X1 $PINS ZN=n_1588 A1=n_739 A2=n_770 B1=n_1685 B2=n_1593 VDD=VDD
+ VSS=VSS
Xi_1112 XNOR2_X1 $PINS ZN=o_mantissa[31] A=n_1589 B=n_1588 VDD=VDD VSS=VSS
Xi_1111 XOR2_X1 $PINS Z=o_mantissa[30] A=n_1593 B=n_1592 VDD=VDD VSS=VSS
Xi_1110 XNOR2_X1 $PINS ZN=o_mantissa[29] A=n_1596 B=n_1595 VDD=VDD VSS=VSS
Xi_1109 AOI21_X1 $PINS ZN=n_1587 A=n_1721 B1=n_669 B2=n_704 VDD=VDD VSS=VSS
Xi_1108 OAI21_X1 $PINS ZN=n_1586 A=n_1679 B1=n_549 B2=n_590 VDD=VDD VSS=VSS
Xi_1107 AOI21_X1 $PINS ZN=n_1585 A=n_1714 B1=n_1679 B2=n_1597 VDD=VDD VSS=VSS
Xi_1106 OAI21_X1 $PINS ZN=n_1584 A=n_1718 B1=n_1677 B2=n_1585 VDD=VDD VSS=VSS
Xi_1105 INV_X1 $PINS ZN=n_1583 A=n_1584 VDD=VDD VSS=VSS
Xi_1104 NOR2_X1 $PINS ZN=n_1582 A1=n_1719 A2=n_1677 VDD=VDD VSS=VSS
Xi_1103 OAI21_X1 $PINS ZN=n_1581 A=n_1716 B1=n_1675 B2=n_1583 VDD=VDD VSS=VSS
Xi_1102 XNOR2_X1 $PINS ZN=o_mantissa[28] A=n_1587 B=n_1581 VDD=VDD VSS=VSS
Xi_1101 NOR2_X1 $PINS ZN=n_1580 A1=n_1717 A2=n_1675 VDD=VDD VSS=VSS
Xi_1100 XOR2_X1 $PINS Z=o_mantissa[27] A=n_1583 B=n_1580 VDD=VDD VSS=VSS
Xi_1099 XOR2_X1 $PINS Z=o_mantissa[26] A=n_1585 B=n_1582 VDD=VDD VSS=VSS
Xi_1098 XOR2_X1 $PINS Z=o_mantissa[25] A=n_1597 B=n_1586 VDD=VDD VSS=VSS
Xi_1097 AOI21_X1 $PINS ZN=n_1579 A=n_1735 B1=n_505 B2=n_548 VDD=VDD VSS=VSS
Xi_1096 OAI21_X1 $PINS ZN=n_1578 A=n_1693 B1=n_379 B2=n_418 VDD=VDD VSS=VSS
Xi_1095 AOI21_X1 $PINS ZN=n_1577 A=n_1736 B1=n_1693 B2=n_1599 VDD=VDD VSS=VSS
Xi_1094 OAI21_X1 $PINS ZN=n_1576 A=n_1732 B1=n_1691 B2=n_1577 VDD=VDD VSS=VSS
Xi_1093 INV_X1 $PINS ZN=n_1575 A=n_1576 VDD=VDD VSS=VSS
Xi_1092 NOR2_X1 $PINS ZN=n_1574 A1=n_1733 A2=n_1691 VDD=VDD VSS=VSS
Xi_1091 OAI21_X1 $PINS ZN=n_1573 A=n_1730 B1=n_1689 B2=n_1575 VDD=VDD VSS=VSS
Xi_1090 XNOR2_X1 $PINS ZN=o_mantissa[24] A=n_1579 B=n_1573 VDD=VDD VSS=VSS
Xi_1089 NOR2_X1 $PINS ZN=n_1572 A1=n_1731 A2=n_1689 VDD=VDD VSS=VSS
Xi_1088 XOR2_X1 $PINS Z=o_mantissa[23] A=n_1575 B=n_1572 VDD=VDD VSS=VSS
Xi_1087 XOR2_X1 $PINS Z=o_mantissa[22] A=n_1577 B=n_1574 VDD=VDD VSS=VSS
Xi_1086 XOR2_X1 $PINS Z=o_mantissa[21] A=n_1599 B=n_1578 VDD=VDD VSS=VSS
Xi_1085 AOI21_X1 $PINS ZN=n_1571 A=n_1710 B1=n_376 B2=n_378 VDD=VDD VSS=VSS
Xi_1084 OAI21_X1 $PINS ZN=n_1570 A=n_1700 B1=n_268 B2=n_270 VDD=VDD VSS=VSS
Xi_1083 AOI21_X1 $PINS ZN=n_1569 A=n_1703 B1=n_1737 B2=n_1700 VDD=VDD VSS=VSS
Xi_1082 OAI21_X1 $PINS ZN=n_1568 A=n_1707 B1=n_1698 B2=n_1569 VDD=VDD VSS=VSS
Xi_1081 INV_X1 $PINS ZN=n_1567 A=n_1568 VDD=VDD VSS=VSS
Xi_1080 NOR2_X1 $PINS ZN=n_1566 A1=n_1708 A2=n_1698 VDD=VDD VSS=VSS
Xi_1079 OAI21_X1 $PINS ZN=n_1565 A=n_1705 B1=n_1696 B2=n_1567 VDD=VDD VSS=VSS
Xi_1078 XNOR2_X1 $PINS ZN=o_mantissa[20] A=n_1571 B=n_1565 VDD=VDD VSS=VSS
Xi_1077 NOR2_X1 $PINS ZN=n_1564 A1=n_1706 A2=n_1696 VDD=VDD VSS=VSS
Xi_1076 XOR2_X1 $PINS Z=o_mantissa[19] A=n_1567 B=n_1564 VDD=VDD VSS=VSS
Xi_1075 XOR2_X1 $PINS Z=o_mantissa[18] A=n_1569 B=n_1566 VDD=VDD VSS=VSS
Xi_1074 XOR2_X1 $PINS Z=o_mantissa[17] A=n_1737 B=n_1570 VDD=VDD VSS=VSS
Xi_1073 NOR2_X1 $PINS ZN=n_1563 A1=n_1750 A2=n_1741 VDD=VDD VSS=VSS
Xi_1072 OAI21_X1 $PINS ZN=n_1562 A=n_1744 B1=n_152 B2=n_154 VDD=VDD VSS=VSS
Xi_1071 AOI21_X1 $PINS ZN=n_1561 A=n_1746 B1=n_1751 B2=n_1744 VDD=VDD VSS=VSS
Xi_1070 INV_X1 $PINS ZN=n_1560 A=n_1561 VDD=VDD VSS=VSS
Xi_1069 AOI21_X1 $PINS ZN=n_1559 A=n_1749 B1=n_1743 B2=n_1560 VDD=VDD VSS=VSS
Xi_1068 AOI21_X1 $PINS ZN=n_1558 A=n_1749 B1=n_178 B2=n_180 VDD=VDD VSS=VSS
Xi_1067 OAI22_X1 $PINS ZN=n_1557 A1=n_206 A2=n_208 B1=n_1739 B2=n_1559 VDD=VDD
+ VSS=VSS
Xi_1066 XNOR2_X1 $PINS ZN=o_mantissa[16] A=n_1563 B=n_1557 VDD=VDD VSS=VSS
Xi_1065 NOR2_X1 $PINS ZN=n_1556 A1=n_1748 A2=n_1739 VDD=VDD VSS=VSS
Xi_1064 XOR2_X1 $PINS Z=o_mantissa[15] A=n_1559 B=n_1556 VDD=VDD VSS=VSS
Xi_1063 XOR2_X1 $PINS Z=o_mantissa[14] A=n_1561 B=n_1558 VDD=VDD VSS=VSS
Xi_1062 XOR2_X1 $PINS Z=o_mantissa[13] A=n_1751 B=n_1562 VDD=VDD VSS=VSS
Xi_1061 NOR2_X1 $PINS ZN=n_1555 A1=n_1764 A2=n_1755 VDD=VDD VSS=VSS
Xi_1060 OAI21_X1 $PINS ZN=n_1554 A=n_1758 B1=n_68 B2=n_70 VDD=VDD VSS=VSS
Xi_1059 AOI21_X1 $PINS ZN=n_1553 A=n_1760 B1=n_1765 B2=n_1758 VDD=VDD VSS=VSS
Xi_1058 INV_X1 $PINS ZN=n_1552 A=n_1553 VDD=VDD VSS=VSS
Xi_1057 AOI21_X1 $PINS ZN=n_1551 A=n_1763 B1=n_1757 B2=n_1552 VDD=VDD VSS=VSS
Xi_1056 AOI21_X1 $PINS ZN=n_1550 A=n_1763 B1=n_86 B2=n_88 VDD=VDD VSS=VSS
Xi_1055 OAI22_X1 $PINS ZN=n_1549 A1=n_106 A2=n_108 B1=n_1753 B2=n_1551 VDD=VDD
+ VSS=VSS
Xi_1054 XNOR2_X1 $PINS ZN=o_mantissa[12] A=n_1555 B=n_1549 VDD=VDD VSS=VSS
Xi_1053 NOR2_X1 $PINS ZN=n_1548 A1=n_1762 A2=n_1753 VDD=VDD VSS=VSS
Xi_1052 XOR2_X1 $PINS Z=o_mantissa[11] A=n_1551 B=n_1548 VDD=VDD VSS=VSS
Xi_1051 XOR2_X1 $PINS Z=o_mantissa[10] A=n_1553 B=n_1550 VDD=VDD VSS=VSS
Xi_1050 XOR2_X1 $PINS Z=o_mantissa[9] A=n_1765 B=n_1554 VDD=VDD VSS=VSS
Xi_1049 NOR2_X1 $PINS ZN=n_1547 A1=n_1778 A2=n_1769 VDD=VDD VSS=VSS
Xi_1048 OAI21_X1 $PINS ZN=n_1546 A=n_1772 B1=n_16 B2=n_18 VDD=VDD VSS=VSS
Xi_1047 AOI21_X1 $PINS ZN=n_1545 A=n_1774 B1=n_1779 B2=n_1772 VDD=VDD VSS=VSS
Xi_1046 INV_X1 $PINS ZN=n_1544 A=n_1545 VDD=VDD VSS=VSS
Xi_1045 AOI21_X1 $PINS ZN=n_1543 A=n_1777 B1=n_1771 B2=n_1544 VDD=VDD VSS=VSS
Xi_1044 AOI21_X1 $PINS ZN=n_1542 A=n_1777 B1=n_26 B2=n_28 VDD=VDD VSS=VSS
Xi_1043 OAI22_X1 $PINS ZN=n_1541 A1=n_38 A2=n_40 B1=n_1767 B2=n_1543 VDD=VDD
+ VSS=VSS
Xi_1042 XNOR2_X1 $PINS ZN=o_mantissa[8] A=n_1547 B=n_1541 VDD=VDD VSS=VSS
Xi_1041 NOR2_X1 $PINS ZN=n_1540 A1=n_1776 A2=n_1767 VDD=VDD VSS=VSS
Xi_1040 XOR2_X1 $PINS Z=o_mantissa[7] A=n_1543 B=n_1540 VDD=VDD VSS=VSS
Xi_1039 XOR2_X1 $PINS Z=o_mantissa[6] A=n_1545 B=n_1542 VDD=VDD VSS=VSS
Xi_1038 XOR2_X1 $PINS Z=o_mantissa[5] A=n_1779 B=n_1546 VDD=VDD VSS=VSS
Xi_1037 XOR2_X1 $PINS Z=n_1539 A=n_6 B=n_10 VDD=VDD VSS=VSS
Xi_1036 XOR2_X1 $PINS Z=o_mantissa[4] A=n_1780 B=n_1539 VDD=VDD VSS=VSS
Xi_1035 OAI21_X1 $PINS ZN=n_1538 A=n_1790 B1=n_2 B2=n_4 VDD=VDD VSS=VSS
Xi_1034 XNOR2_X1 $PINS ZN=o_mantissa[3] A=n_1782 B=n_1538 VDD=VDD VSS=VSS
Xi_1033 OAI21_X1 $PINS ZN=n_1537 A=n_1783 B1=n_0 B2=n_1789 VDD=VDD VSS=VSS
Xi_1032 XOR2_X1 $PINS Z=o_mantissa[2] A=n_1784 B=n_1537 VDD=VDD VSS=VSS
Xi_1031 OAI21_X1 $PINS ZN=n_1536 A=n_1784 B1=n_1787 B2=n_1786 VDD=VDD VSS=VSS
Xi_1030 INV_X1 $PINS ZN=o_mantissa[1] A=n_1536 VDD=VDD VSS=VSS
Xi_1029 NOR2_X1 $PINS ZN=n_1535 A1=n_1817 A2=n_1797 VDD=VDD VSS=VSS
Xi_1028 NOR2_X1 $PINS ZN=n_1534 A1=n_1817 A2=n_1798 VDD=VDD VSS=VSS
Xi_1027 NOR2_X1 $PINS ZN=n_1533 A1=n_1817 A2=n_1799 VDD=VDD VSS=VSS
Xi_1026 NOR2_X1 $PINS ZN=n_1532 A1=n_1817 A2=n_1800 VDD=VDD VSS=VSS
Xi_1025 NOR2_X1 $PINS ZN=n_1531 A1=n_1817 A2=n_1801 VDD=VDD VSS=VSS
Xi_1024 NOR2_X1 $PINS ZN=n_1530 A1=n_1817 A2=n_1802 VDD=VDD VSS=VSS
Xi_1023 NOR2_X1 $PINS ZN=n_1529 A1=n_1817 A2=n_1803 VDD=VDD VSS=VSS
Xi_1022 NOR2_X1 $PINS ZN=n_1528 A1=n_1817 A2=n_1804 VDD=VDD VSS=VSS
Xi_1021 NOR2_X1 $PINS ZN=n_1527 A1=n_1817 A2=n_1805 VDD=VDD VSS=VSS
Xi_1020 NOR2_X1 $PINS ZN=n_1526 A1=n_1817 A2=n_1806 VDD=VDD VSS=VSS
Xi_1019 NOR2_X1 $PINS ZN=n_1525 A1=n_1817 A2=n_1807 VDD=VDD VSS=VSS
Xi_1018 NOR2_X1 $PINS ZN=n_1524 A1=n_1817 A2=n_1808 VDD=VDD VSS=VSS
Xi_1017 NOR2_X1 $PINS ZN=n_1523 A1=n_1817 A2=n_1809 VDD=VDD VSS=VSS
Xi_1016 NOR2_X1 $PINS ZN=n_1522 A1=n_1817 A2=n_1810 VDD=VDD VSS=VSS
Xi_1015 NOR2_X1 $PINS ZN=n_1521 A1=n_1817 A2=n_1811 VDD=VDD VSS=VSS
Xi_1014 NOR2_X1 $PINS ZN=n_1520 A1=n_1817 A2=n_1812 VDD=VDD VSS=VSS
Xi_1013 NOR2_X1 $PINS ZN=n_1519 A1=n_1817 A2=n_1813 VDD=VDD VSS=VSS
Xi_1012 NOR2_X1 $PINS ZN=n_1518 A1=n_1817 A2=n_1814 VDD=VDD VSS=VSS
Xi_1011 NOR2_X1 $PINS ZN=n_1517 A1=n_1817 A2=n_1815 VDD=VDD VSS=VSS
Xi_1010 NOR2_X1 $PINS ZN=n_1516 A1=n_1817 A2=n_1816 VDD=VDD VSS=VSS
Xi_1009 NOR2_X1 $PINS ZN=n_1515 A1=n_1818 A2=n_1796 VDD=VDD VSS=VSS
Xi_1008 NOR2_X1 $PINS ZN=n_1514 A1=n_1818 A2=n_1797 VDD=VDD VSS=VSS
Xi_1007 NOR2_X1 $PINS ZN=n_1513 A1=n_1818 A2=n_1798 VDD=VDD VSS=VSS
Xi_1006 NOR2_X1 $PINS ZN=n_1512 A1=n_1818 A2=n_1799 VDD=VDD VSS=VSS
Xi_1005 NOR2_X1 $PINS ZN=n_1511 A1=n_1818 A2=n_1800 VDD=VDD VSS=VSS
Xi_1004 NOR2_X1 $PINS ZN=n_1510 A1=n_1818 A2=n_1801 VDD=VDD VSS=VSS
Xi_1003 NOR2_X1 $PINS ZN=n_1509 A1=n_1818 A2=n_1802 VDD=VDD VSS=VSS
Xi_1002 NOR2_X1 $PINS ZN=n_1508 A1=n_1818 A2=n_1803 VDD=VDD VSS=VSS
Xi_1001 NOR2_X1 $PINS ZN=n_1507 A1=n_1818 A2=n_1804 VDD=VDD VSS=VSS
Xi_1000 NOR2_X1 $PINS ZN=n_1506 A1=n_1818 A2=n_1805 VDD=VDD VSS=VSS
Xi_999 NOR2_X1 $PINS ZN=n_1505 A1=n_1818 A2=n_1806 VDD=VDD VSS=VSS
Xi_998 NOR2_X1 $PINS ZN=n_1504 A1=n_1818 A2=n_1807 VDD=VDD VSS=VSS
Xi_997 NOR2_X1 $PINS ZN=n_1503 A1=n_1818 A2=n_1808 VDD=VDD VSS=VSS
Xi_996 NOR2_X1 $PINS ZN=n_1502 A1=n_1818 A2=n_1809 VDD=VDD VSS=VSS
Xi_995 NOR2_X1 $PINS ZN=n_1501 A1=n_1818 A2=n_1810 VDD=VDD VSS=VSS
Xi_994 NOR2_X1 $PINS ZN=n_1500 A1=n_1818 A2=n_1811 VDD=VDD VSS=VSS
Xi_993 NOR2_X1 $PINS ZN=n_1499 A1=n_1818 A2=n_1812 VDD=VDD VSS=VSS
Xi_992 NOR2_X1 $PINS ZN=n_1498 A1=n_1818 A2=n_1813 VDD=VDD VSS=VSS
Xi_991 NOR2_X1 $PINS ZN=n_1497 A1=n_1818 A2=n_1814 VDD=VDD VSS=VSS
Xi_990 NOR2_X1 $PINS ZN=n_1496 A1=n_1818 A2=n_1815 VDD=VDD VSS=VSS
Xi_989 NOR2_X1 $PINS ZN=n_1495 A1=n_1818 A2=n_1816 VDD=VDD VSS=VSS
Xi_988 NOR2_X1 $PINS ZN=n_1494 A1=n_1819 A2=n_1794 VDD=VDD VSS=VSS
Xi_987 NOR2_X1 $PINS ZN=n_1493 A1=n_1819 A2=n_1795 VDD=VDD VSS=VSS
Xi_986 NOR2_X1 $PINS ZN=n_1492 A1=n_1819 A2=n_1796 VDD=VDD VSS=VSS
Xi_985 NOR2_X1 $PINS ZN=n_1491 A1=n_1819 A2=n_1797 VDD=VDD VSS=VSS
Xi_984 NOR2_X1 $PINS ZN=n_1490 A1=n_1819 A2=n_1798 VDD=VDD VSS=VSS
Xi_983 NOR2_X1 $PINS ZN=n_1489 A1=n_1819 A2=n_1799 VDD=VDD VSS=VSS
Xi_982 NOR2_X1 $PINS ZN=n_1488 A1=n_1819 A2=n_1800 VDD=VDD VSS=VSS
Xi_981 NOR2_X1 $PINS ZN=n_1487 A1=n_1819 A2=n_1801 VDD=VDD VSS=VSS
Xi_980 NOR2_X1 $PINS ZN=n_1486 A1=n_1819 A2=n_1802 VDD=VDD VSS=VSS
Xi_979 NOR2_X1 $PINS ZN=n_1485 A1=n_1819 A2=n_1803 VDD=VDD VSS=VSS
Xi_978 NOR2_X1 $PINS ZN=n_1484 A1=n_1819 A2=n_1804 VDD=VDD VSS=VSS
Xi_977 NOR2_X1 $PINS ZN=n_1483 A1=n_1819 A2=n_1805 VDD=VDD VSS=VSS
Xi_976 NOR2_X1 $PINS ZN=n_1482 A1=n_1819 A2=n_1806 VDD=VDD VSS=VSS
Xi_975 NOR2_X1 $PINS ZN=n_1481 A1=n_1819 A2=n_1807 VDD=VDD VSS=VSS
Xi_974 NOR2_X1 $PINS ZN=n_1480 A1=n_1819 A2=n_1808 VDD=VDD VSS=VSS
Xi_973 NOR2_X1 $PINS ZN=n_1479 A1=n_1819 A2=n_1809 VDD=VDD VSS=VSS
Xi_972 NOR2_X1 $PINS ZN=n_1478 A1=n_1819 A2=n_1810 VDD=VDD VSS=VSS
Xi_971 NOR2_X1 $PINS ZN=n_1477 A1=n_1819 A2=n_1811 VDD=VDD VSS=VSS
Xi_970 NOR2_X1 $PINS ZN=n_1476 A1=n_1819 A2=n_1812 VDD=VDD VSS=VSS
Xi_969 NOR2_X1 $PINS ZN=n_1475 A1=n_1819 A2=n_1813 VDD=VDD VSS=VSS
Xi_968 NOR2_X1 $PINS ZN=n_1474 A1=n_1819 A2=n_1814 VDD=VDD VSS=VSS
Xi_967 NOR2_X1 $PINS ZN=n_1473 A1=n_1819 A2=n_1815 VDD=VDD VSS=VSS
Xi_966 NOR2_X1 $PINS ZN=n_1472 A1=n_1819 A2=n_1816 VDD=VDD VSS=VSS
Xi_965 NOR2_X1 $PINS ZN=n_1471 A1=n_1820 A2=n_1794 VDD=VDD VSS=VSS
Xi_964 NOR2_X1 $PINS ZN=n_1470 A1=n_1820 A2=n_1795 VDD=VDD VSS=VSS
Xi_963 NOR2_X1 $PINS ZN=n_1469 A1=n_1820 A2=n_1796 VDD=VDD VSS=VSS
Xi_962 NOR2_X1 $PINS ZN=n_1468 A1=n_1820 A2=n_1797 VDD=VDD VSS=VSS
Xi_961 NOR2_X1 $PINS ZN=n_1467 A1=n_1820 A2=n_1798 VDD=VDD VSS=VSS
Xi_960 NOR2_X1 $PINS ZN=n_1466 A1=n_1820 A2=n_1799 VDD=VDD VSS=VSS
Xi_959 NOR2_X1 $PINS ZN=n_1465 A1=n_1820 A2=n_1800 VDD=VDD VSS=VSS
Xi_958 NOR2_X1 $PINS ZN=n_1464 A1=n_1820 A2=n_1801 VDD=VDD VSS=VSS
Xi_957 NOR2_X1 $PINS ZN=n_1463 A1=n_1820 A2=n_1802 VDD=VDD VSS=VSS
Xi_956 NOR2_X1 $PINS ZN=n_1462 A1=n_1820 A2=n_1803 VDD=VDD VSS=VSS
Xi_955 NOR2_X1 $PINS ZN=n_1461 A1=n_1820 A2=n_1804 VDD=VDD VSS=VSS
Xi_954 NOR2_X1 $PINS ZN=n_1460 A1=n_1820 A2=n_1805 VDD=VDD VSS=VSS
Xi_953 NOR2_X1 $PINS ZN=n_1459 A1=n_1820 A2=n_1806 VDD=VDD VSS=VSS
Xi_952 NOR2_X1 $PINS ZN=n_1458 A1=n_1820 A2=n_1807 VDD=VDD VSS=VSS
Xi_951 NOR2_X1 $PINS ZN=n_1457 A1=n_1820 A2=n_1808 VDD=VDD VSS=VSS
Xi_950 NOR2_X1 $PINS ZN=n_1456 A1=n_1820 A2=n_1809 VDD=VDD VSS=VSS
Xi_949 NOR2_X1 $PINS ZN=n_1455 A1=n_1820 A2=n_1810 VDD=VDD VSS=VSS
Xi_948 NOR2_X1 $PINS ZN=n_1454 A1=n_1820 A2=n_1811 VDD=VDD VSS=VSS
Xi_947 NOR2_X1 $PINS ZN=n_1453 A1=n_1820 A2=n_1812 VDD=VDD VSS=VSS
Xi_946 NOR2_X1 $PINS ZN=n_1452 A1=n_1820 A2=n_1813 VDD=VDD VSS=VSS
Xi_945 NOR2_X1 $PINS ZN=n_1451 A1=n_1820 A2=n_1814 VDD=VDD VSS=VSS
Xi_944 NOR2_X1 $PINS ZN=n_1450 A1=n_1820 A2=n_1815 VDD=VDD VSS=VSS
Xi_943 NOR2_X1 $PINS ZN=n_1449 A1=n_1820 A2=n_1816 VDD=VDD VSS=VSS
Xi_942 NOR2_X1 $PINS ZN=n_1448 A1=n_1821 A2=n_1794 VDD=VDD VSS=VSS
Xi_941 NOR2_X1 $PINS ZN=n_1447 A1=n_1821 A2=n_1795 VDD=VDD VSS=VSS
Xi_940 NOR2_X1 $PINS ZN=n_1446 A1=n_1821 A2=n_1796 VDD=VDD VSS=VSS
Xi_939 NOR2_X1 $PINS ZN=n_1445 A1=n_1821 A2=n_1797 VDD=VDD VSS=VSS
Xi_938 NOR2_X1 $PINS ZN=n_1444 A1=n_1821 A2=n_1798 VDD=VDD VSS=VSS
Xi_937 NOR2_X1 $PINS ZN=n_1443 A1=n_1821 A2=n_1799 VDD=VDD VSS=VSS
Xi_936 NOR2_X1 $PINS ZN=n_1442 A1=n_1821 A2=n_1800 VDD=VDD VSS=VSS
Xi_935 NOR2_X1 $PINS ZN=n_1441 A1=n_1821 A2=n_1801 VDD=VDD VSS=VSS
Xi_934 NOR2_X1 $PINS ZN=n_1440 A1=n_1821 A2=n_1802 VDD=VDD VSS=VSS
Xi_933 NOR2_X1 $PINS ZN=n_1439 A1=n_1821 A2=n_1803 VDD=VDD VSS=VSS
Xi_932 NOR2_X1 $PINS ZN=n_1438 A1=n_1821 A2=n_1804 VDD=VDD VSS=VSS
Xi_931 NOR2_X1 $PINS ZN=n_1437 A1=n_1821 A2=n_1805 VDD=VDD VSS=VSS
Xi_930 NOR2_X1 $PINS ZN=n_1436 A1=n_1821 A2=n_1806 VDD=VDD VSS=VSS
Xi_929 NOR2_X1 $PINS ZN=n_1435 A1=n_1821 A2=n_1807 VDD=VDD VSS=VSS
Xi_928 NOR2_X1 $PINS ZN=n_1434 A1=n_1821 A2=n_1808 VDD=VDD VSS=VSS
Xi_927 NOR2_X1 $PINS ZN=n_1433 A1=n_1821 A2=n_1809 VDD=VDD VSS=VSS
Xi_926 NOR2_X1 $PINS ZN=n_1432 A1=n_1821 A2=n_1810 VDD=VDD VSS=VSS
Xi_925 NOR2_X1 $PINS ZN=n_1431 A1=n_1821 A2=n_1811 VDD=VDD VSS=VSS
Xi_924 NOR2_X1 $PINS ZN=n_1430 A1=n_1821 A2=n_1812 VDD=VDD VSS=VSS
Xi_923 NOR2_X1 $PINS ZN=n_1429 A1=n_1821 A2=n_1813 VDD=VDD VSS=VSS
Xi_922 NOR2_X1 $PINS ZN=n_1428 A1=n_1821 A2=n_1814 VDD=VDD VSS=VSS
Xi_921 NOR2_X1 $PINS ZN=n_1427 A1=n_1821 A2=n_1815 VDD=VDD VSS=VSS
Xi_920 NOR2_X1 $PINS ZN=n_1426 A1=n_1821 A2=n_1816 VDD=VDD VSS=VSS
Xi_919 NOR2_X1 $PINS ZN=n_1425 A1=n_1822 A2=n_1794 VDD=VDD VSS=VSS
Xi_918 NOR2_X1 $PINS ZN=n_1424 A1=n_1822 A2=n_1795 VDD=VDD VSS=VSS
Xi_917 NOR2_X1 $PINS ZN=n_1423 A1=n_1822 A2=n_1796 VDD=VDD VSS=VSS
Xi_916 NOR2_X1 $PINS ZN=n_1422 A1=n_1822 A2=n_1797 VDD=VDD VSS=VSS
Xi_915 NOR2_X1 $PINS ZN=n_1421 A1=n_1822 A2=n_1798 VDD=VDD VSS=VSS
Xi_914 NOR2_X1 $PINS ZN=n_1420 A1=n_1822 A2=n_1799 VDD=VDD VSS=VSS
Xi_913 NOR2_X1 $PINS ZN=n_1419 A1=n_1822 A2=n_1800 VDD=VDD VSS=VSS
Xi_912 NOR2_X1 $PINS ZN=n_1418 A1=n_1822 A2=n_1801 VDD=VDD VSS=VSS
Xi_911 NOR2_X1 $PINS ZN=n_1417 A1=n_1822 A2=n_1802 VDD=VDD VSS=VSS
Xi_910 NOR2_X1 $PINS ZN=n_1416 A1=n_1822 A2=n_1803 VDD=VDD VSS=VSS
Xi_909 NOR2_X1 $PINS ZN=n_1415 A1=n_1822 A2=n_1804 VDD=VDD VSS=VSS
Xi_908 NOR2_X1 $PINS ZN=n_1414 A1=n_1822 A2=n_1805 VDD=VDD VSS=VSS
Xi_907 NOR2_X1 $PINS ZN=n_1413 A1=n_1822 A2=n_1806 VDD=VDD VSS=VSS
Xi_906 NOR2_X1 $PINS ZN=n_1412 A1=n_1822 A2=n_1807 VDD=VDD VSS=VSS
Xi_905 NOR2_X1 $PINS ZN=n_1411 A1=n_1822 A2=n_1808 VDD=VDD VSS=VSS
Xi_904 NOR2_X1 $PINS ZN=n_1410 A1=n_1822 A2=n_1809 VDD=VDD VSS=VSS
Xi_903 NOR2_X1 $PINS ZN=n_1409 A1=n_1822 A2=n_1810 VDD=VDD VSS=VSS
Xi_902 NOR2_X1 $PINS ZN=n_1408 A1=n_1822 A2=n_1811 VDD=VDD VSS=VSS
Xi_901 NOR2_X1 $PINS ZN=n_1407 A1=n_1822 A2=n_1812 VDD=VDD VSS=VSS
Xi_900 NOR2_X1 $PINS ZN=n_1406 A1=n_1822 A2=n_1813 VDD=VDD VSS=VSS
Xi_899 NOR2_X1 $PINS ZN=n_1405 A1=n_1822 A2=n_1814 VDD=VDD VSS=VSS
Xi_898 NOR2_X1 $PINS ZN=n_1404 A1=n_1822 A2=n_1815 VDD=VDD VSS=VSS
Xi_897 NOR2_X1 $PINS ZN=n_1403 A1=n_1822 A2=n_1816 VDD=VDD VSS=VSS
Xi_896 NOR2_X1 $PINS ZN=n_1402 A1=n_1823 A2=n_1794 VDD=VDD VSS=VSS
Xi_895 NOR2_X1 $PINS ZN=n_1401 A1=n_1823 A2=n_1795 VDD=VDD VSS=VSS
Xi_894 NOR2_X1 $PINS ZN=n_1400 A1=n_1823 A2=n_1796 VDD=VDD VSS=VSS
Xi_893 NOR2_X1 $PINS ZN=n_1399 A1=n_1823 A2=n_1797 VDD=VDD VSS=VSS
Xi_892 NOR2_X1 $PINS ZN=n_1398 A1=n_1823 A2=n_1798 VDD=VDD VSS=VSS
Xi_891 NOR2_X1 $PINS ZN=n_1397 A1=n_1823 A2=n_1799 VDD=VDD VSS=VSS
Xi_890 NOR2_X1 $PINS ZN=n_1396 A1=n_1823 A2=n_1800 VDD=VDD VSS=VSS
Xi_889 NOR2_X1 $PINS ZN=n_1395 A1=n_1823 A2=n_1801 VDD=VDD VSS=VSS
Xi_888 NOR2_X1 $PINS ZN=n_1394 A1=n_1823 A2=n_1802 VDD=VDD VSS=VSS
Xi_887 NOR2_X1 $PINS ZN=n_1393 A1=n_1823 A2=n_1803 VDD=VDD VSS=VSS
Xi_886 NOR2_X1 $PINS ZN=n_1392 A1=n_1823 A2=n_1804 VDD=VDD VSS=VSS
Xi_885 NOR2_X1 $PINS ZN=n_1391 A1=n_1823 A2=n_1805 VDD=VDD VSS=VSS
Xi_884 NOR2_X1 $PINS ZN=n_1390 A1=n_1823 A2=n_1806 VDD=VDD VSS=VSS
Xi_883 NOR2_X1 $PINS ZN=n_1389 A1=n_1823 A2=n_1807 VDD=VDD VSS=VSS
Xi_882 NOR2_X1 $PINS ZN=n_1388 A1=n_1823 A2=n_1808 VDD=VDD VSS=VSS
Xi_881 NOR2_X1 $PINS ZN=n_1387 A1=n_1823 A2=n_1809 VDD=VDD VSS=VSS
Xi_880 NOR2_X1 $PINS ZN=n_1386 A1=n_1823 A2=n_1810 VDD=VDD VSS=VSS
Xi_879 NOR2_X1 $PINS ZN=n_1385 A1=n_1823 A2=n_1811 VDD=VDD VSS=VSS
Xi_878 NOR2_X1 $PINS ZN=n_1384 A1=n_1823 A2=n_1812 VDD=VDD VSS=VSS
Xi_877 NOR2_X1 $PINS ZN=n_1383 A1=n_1823 A2=n_1813 VDD=VDD VSS=VSS
Xi_876 NOR2_X1 $PINS ZN=n_1382 A1=n_1823 A2=n_1814 VDD=VDD VSS=VSS
Xi_875 NOR2_X1 $PINS ZN=n_1381 A1=n_1823 A2=n_1815 VDD=VDD VSS=VSS
Xi_874 NOR2_X1 $PINS ZN=n_1380 A1=n_1823 A2=n_1816 VDD=VDD VSS=VSS
Xi_873 NOR2_X1 $PINS ZN=n_1379 A1=n_1824 A2=n_1794 VDD=VDD VSS=VSS
Xi_872 NOR2_X1 $PINS ZN=n_1378 A1=n_1824 A2=n_1795 VDD=VDD VSS=VSS
Xi_871 NOR2_X1 $PINS ZN=n_1377 A1=n_1824 A2=n_1796 VDD=VDD VSS=VSS
Xi_870 NOR2_X1 $PINS ZN=n_1376 A1=n_1824 A2=n_1797 VDD=VDD VSS=VSS
Xi_869 NOR2_X1 $PINS ZN=n_1375 A1=n_1824 A2=n_1798 VDD=VDD VSS=VSS
Xi_868 NOR2_X1 $PINS ZN=n_1374 A1=n_1824 A2=n_1799 VDD=VDD VSS=VSS
Xi_867 NOR2_X1 $PINS ZN=n_1373 A1=n_1824 A2=n_1800 VDD=VDD VSS=VSS
Xi_866 NOR2_X1 $PINS ZN=n_1372 A1=n_1824 A2=n_1801 VDD=VDD VSS=VSS
Xi_865 NOR2_X1 $PINS ZN=n_1371 A1=n_1824 A2=n_1802 VDD=VDD VSS=VSS
Xi_864 NOR2_X1 $PINS ZN=n_1370 A1=n_1824 A2=n_1803 VDD=VDD VSS=VSS
Xi_863 NOR2_X1 $PINS ZN=n_1369 A1=n_1824 A2=n_1804 VDD=VDD VSS=VSS
Xi_862 NOR2_X1 $PINS ZN=n_1368 A1=n_1824 A2=n_1805 VDD=VDD VSS=VSS
Xi_861 NOR2_X1 $PINS ZN=n_1367 A1=n_1824 A2=n_1806 VDD=VDD VSS=VSS
Xi_860 NOR2_X1 $PINS ZN=n_1366 A1=n_1824 A2=n_1807 VDD=VDD VSS=VSS
Xi_859 NOR2_X1 $PINS ZN=n_1365 A1=n_1824 A2=n_1808 VDD=VDD VSS=VSS
Xi_858 NOR2_X1 $PINS ZN=n_1364 A1=n_1824 A2=n_1809 VDD=VDD VSS=VSS
Xi_857 NOR2_X1 $PINS ZN=n_1363 A1=n_1824 A2=n_1810 VDD=VDD VSS=VSS
Xi_856 NOR2_X1 $PINS ZN=n_1362 A1=n_1824 A2=n_1811 VDD=VDD VSS=VSS
Xi_855 NOR2_X1 $PINS ZN=n_1361 A1=n_1824 A2=n_1812 VDD=VDD VSS=VSS
Xi_854 NOR2_X1 $PINS ZN=n_1360 A1=n_1824 A2=n_1813 VDD=VDD VSS=VSS
Xi_853 NOR2_X1 $PINS ZN=n_1359 A1=n_1824 A2=n_1814 VDD=VDD VSS=VSS
Xi_852 NOR2_X1 $PINS ZN=n_1358 A1=n_1824 A2=n_1815 VDD=VDD VSS=VSS
Xi_851 NOR2_X1 $PINS ZN=n_1357 A1=n_1824 A2=n_1816 VDD=VDD VSS=VSS
Xi_850 NOR2_X1 $PINS ZN=n_1356 A1=n_1825 A2=n_1794 VDD=VDD VSS=VSS
Xi_849 NOR2_X1 $PINS ZN=n_1355 A1=n_1825 A2=n_1795 VDD=VDD VSS=VSS
Xi_848 NOR2_X1 $PINS ZN=n_1354 A1=n_1825 A2=n_1796 VDD=VDD VSS=VSS
Xi_847 NOR2_X1 $PINS ZN=n_1353 A1=n_1825 A2=n_1797 VDD=VDD VSS=VSS
Xi_846 NOR2_X1 $PINS ZN=n_1352 A1=n_1825 A2=n_1798 VDD=VDD VSS=VSS
Xi_845 NOR2_X1 $PINS ZN=n_1351 A1=n_1825 A2=n_1799 VDD=VDD VSS=VSS
Xi_844 NOR2_X1 $PINS ZN=n_1350 A1=n_1825 A2=n_1800 VDD=VDD VSS=VSS
Xi_843 NOR2_X1 $PINS ZN=n_1349 A1=n_1825 A2=n_1801 VDD=VDD VSS=VSS
Xi_842 NOR2_X1 $PINS ZN=n_1348 A1=n_1825 A2=n_1802 VDD=VDD VSS=VSS
Xi_841 NOR2_X1 $PINS ZN=n_1347 A1=n_1825 A2=n_1803 VDD=VDD VSS=VSS
Xi_840 NOR2_X1 $PINS ZN=n_1346 A1=n_1825 A2=n_1804 VDD=VDD VSS=VSS
Xi_839 NOR2_X1 $PINS ZN=n_1345 A1=n_1825 A2=n_1805 VDD=VDD VSS=VSS
Xi_838 NOR2_X1 $PINS ZN=n_1344 A1=n_1825 A2=n_1806 VDD=VDD VSS=VSS
Xi_837 NOR2_X1 $PINS ZN=n_1343 A1=n_1825 A2=n_1807 VDD=VDD VSS=VSS
Xi_836 NOR2_X1 $PINS ZN=n_1342 A1=n_1825 A2=n_1808 VDD=VDD VSS=VSS
Xi_835 NOR2_X1 $PINS ZN=n_1341 A1=n_1825 A2=n_1809 VDD=VDD VSS=VSS
Xi_834 NOR2_X1 $PINS ZN=n_1340 A1=n_1825 A2=n_1810 VDD=VDD VSS=VSS
Xi_833 NOR2_X1 $PINS ZN=n_1339 A1=n_1825 A2=n_1811 VDD=VDD VSS=VSS
Xi_832 NOR2_X1 $PINS ZN=n_1338 A1=n_1825 A2=n_1812 VDD=VDD VSS=VSS
Xi_831 NOR2_X1 $PINS ZN=n_1337 A1=n_1825 A2=n_1813 VDD=VDD VSS=VSS
Xi_830 NOR2_X1 $PINS ZN=n_1336 A1=n_1825 A2=n_1814 VDD=VDD VSS=VSS
Xi_829 NOR2_X1 $PINS ZN=n_1335 A1=n_1825 A2=n_1815 VDD=VDD VSS=VSS
Xi_828 NOR2_X1 $PINS ZN=n_1334 A1=n_1825 A2=n_1816 VDD=VDD VSS=VSS
Xi_827 NOR2_X1 $PINS ZN=n_1333 A1=n_1826 A2=n_1794 VDD=VDD VSS=VSS
Xi_826 NOR2_X1 $PINS ZN=n_1332 A1=n_1826 A2=n_1795 VDD=VDD VSS=VSS
Xi_825 NOR2_X1 $PINS ZN=n_1331 A1=n_1826 A2=n_1796 VDD=VDD VSS=VSS
Xi_824 NOR2_X1 $PINS ZN=n_1330 A1=n_1826 A2=n_1797 VDD=VDD VSS=VSS
Xi_823 NOR2_X1 $PINS ZN=n_1329 A1=n_1826 A2=n_1798 VDD=VDD VSS=VSS
Xi_822 NOR2_X1 $PINS ZN=n_1328 A1=n_1826 A2=n_1799 VDD=VDD VSS=VSS
Xi_821 NOR2_X1 $PINS ZN=n_1327 A1=n_1826 A2=n_1800 VDD=VDD VSS=VSS
Xi_820 NOR2_X1 $PINS ZN=n_1326 A1=n_1826 A2=n_1801 VDD=VDD VSS=VSS
Xi_819 NOR2_X1 $PINS ZN=n_1325 A1=n_1826 A2=n_1802 VDD=VDD VSS=VSS
Xi_818 NOR2_X1 $PINS ZN=n_1324 A1=n_1826 A2=n_1803 VDD=VDD VSS=VSS
Xi_817 NOR2_X1 $PINS ZN=n_1323 A1=n_1826 A2=n_1804 VDD=VDD VSS=VSS
Xi_816 NOR2_X1 $PINS ZN=n_1322 A1=n_1826 A2=n_1805 VDD=VDD VSS=VSS
Xi_815 NOR2_X1 $PINS ZN=n_1321 A1=n_1826 A2=n_1806 VDD=VDD VSS=VSS
Xi_814 NOR2_X1 $PINS ZN=n_1320 A1=n_1826 A2=n_1807 VDD=VDD VSS=VSS
Xi_813 NOR2_X1 $PINS ZN=n_1319 A1=n_1826 A2=n_1808 VDD=VDD VSS=VSS
Xi_812 NOR2_X1 $PINS ZN=n_1318 A1=n_1826 A2=n_1809 VDD=VDD VSS=VSS
Xi_811 NOR2_X1 $PINS ZN=n_1317 A1=n_1826 A2=n_1810 VDD=VDD VSS=VSS
Xi_810 NOR2_X1 $PINS ZN=n_1316 A1=n_1826 A2=n_1811 VDD=VDD VSS=VSS
Xi_809 NOR2_X1 $PINS ZN=n_1315 A1=n_1826 A2=n_1812 VDD=VDD VSS=VSS
Xi_808 NOR2_X1 $PINS ZN=n_1314 A1=n_1826 A2=n_1813 VDD=VDD VSS=VSS
Xi_807 NOR2_X1 $PINS ZN=n_1313 A1=n_1826 A2=n_1814 VDD=VDD VSS=VSS
Xi_806 NOR2_X1 $PINS ZN=n_1312 A1=n_1826 A2=n_1815 VDD=VDD VSS=VSS
Xi_805 NOR2_X1 $PINS ZN=n_1311 A1=n_1826 A2=n_1816 VDD=VDD VSS=VSS
Xi_804 NOR2_X1 $PINS ZN=n_1310 A1=n_1827 A2=n_1794 VDD=VDD VSS=VSS
Xi_803 NOR2_X1 $PINS ZN=n_1309 A1=n_1827 A2=n_1795 VDD=VDD VSS=VSS
Xi_802 NOR2_X1 $PINS ZN=n_1308 A1=n_1827 A2=n_1796 VDD=VDD VSS=VSS
Xi_801 NOR2_X1 $PINS ZN=n_1307 A1=n_1827 A2=n_1797 VDD=VDD VSS=VSS
Xi_800 NOR2_X1 $PINS ZN=n_1306 A1=n_1827 A2=n_1798 VDD=VDD VSS=VSS
Xi_799 NOR2_X1 $PINS ZN=n_1305 A1=n_1827 A2=n_1799 VDD=VDD VSS=VSS
Xi_798 NOR2_X1 $PINS ZN=n_1304 A1=n_1827 A2=n_1800 VDD=VDD VSS=VSS
Xi_797 NOR2_X1 $PINS ZN=n_1303 A1=n_1827 A2=n_1801 VDD=VDD VSS=VSS
Xi_796 NOR2_X1 $PINS ZN=n_1302 A1=n_1827 A2=n_1802 VDD=VDD VSS=VSS
Xi_795 NOR2_X1 $PINS ZN=n_1301 A1=n_1827 A2=n_1803 VDD=VDD VSS=VSS
Xi_794 NOR2_X1 $PINS ZN=n_1300 A1=n_1827 A2=n_1804 VDD=VDD VSS=VSS
Xi_793 NOR2_X1 $PINS ZN=n_1299 A1=n_1827 A2=n_1805 VDD=VDD VSS=VSS
Xi_792 NOR2_X1 $PINS ZN=n_1298 A1=n_1827 A2=n_1806 VDD=VDD VSS=VSS
Xi_791 NOR2_X1 $PINS ZN=n_1297 A1=n_1827 A2=n_1807 VDD=VDD VSS=VSS
Xi_790 NOR2_X1 $PINS ZN=n_1296 A1=n_1827 A2=n_1808 VDD=VDD VSS=VSS
Xi_789 NOR2_X1 $PINS ZN=n_1295 A1=n_1827 A2=n_1809 VDD=VDD VSS=VSS
Xi_788 NOR2_X1 $PINS ZN=n_1294 A1=n_1827 A2=n_1810 VDD=VDD VSS=VSS
Xi_787 NOR2_X1 $PINS ZN=n_1293 A1=n_1827 A2=n_1811 VDD=VDD VSS=VSS
Xi_786 NOR2_X1 $PINS ZN=n_1292 A1=n_1827 A2=n_1812 VDD=VDD VSS=VSS
Xi_785 NOR2_X1 $PINS ZN=n_1291 A1=n_1827 A2=n_1813 VDD=VDD VSS=VSS
Xi_784 NOR2_X1 $PINS ZN=n_1290 A1=n_1827 A2=n_1814 VDD=VDD VSS=VSS
Xi_783 NOR2_X1 $PINS ZN=n_1289 A1=n_1827 A2=n_1815 VDD=VDD VSS=VSS
Xi_782 NOR2_X1 $PINS ZN=n_1288 A1=n_1827 A2=n_1816 VDD=VDD VSS=VSS
Xi_781 NOR2_X1 $PINS ZN=n_1287 A1=n_1828 A2=n_1794 VDD=VDD VSS=VSS
Xi_780 NOR2_X1 $PINS ZN=n_1286 A1=n_1828 A2=n_1795 VDD=VDD VSS=VSS
Xi_779 NOR2_X1 $PINS ZN=n_1285 A1=n_1828 A2=n_1796 VDD=VDD VSS=VSS
Xi_778 NOR2_X1 $PINS ZN=n_1284 A1=n_1828 A2=n_1797 VDD=VDD VSS=VSS
Xi_777 NOR2_X1 $PINS ZN=n_1283 A1=n_1828 A2=n_1798 VDD=VDD VSS=VSS
Xi_776 NOR2_X1 $PINS ZN=n_1282 A1=n_1828 A2=n_1799 VDD=VDD VSS=VSS
Xi_775 NOR2_X1 $PINS ZN=n_1281 A1=n_1828 A2=n_1800 VDD=VDD VSS=VSS
Xi_774 NOR2_X1 $PINS ZN=n_1280 A1=n_1828 A2=n_1801 VDD=VDD VSS=VSS
Xi_773 NOR2_X1 $PINS ZN=n_1279 A1=n_1828 A2=n_1802 VDD=VDD VSS=VSS
Xi_772 NOR2_X1 $PINS ZN=n_1278 A1=n_1828 A2=n_1803 VDD=VDD VSS=VSS
Xi_771 NOR2_X1 $PINS ZN=n_1277 A1=n_1828 A2=n_1804 VDD=VDD VSS=VSS
Xi_770 NOR2_X1 $PINS ZN=n_1276 A1=n_1828 A2=n_1805 VDD=VDD VSS=VSS
Xi_769 NOR2_X1 $PINS ZN=n_1275 A1=n_1828 A2=n_1806 VDD=VDD VSS=VSS
Xi_768 NOR2_X1 $PINS ZN=n_1274 A1=n_1828 A2=n_1807 VDD=VDD VSS=VSS
Xi_767 NOR2_X1 $PINS ZN=n_1273 A1=n_1828 A2=n_1808 VDD=VDD VSS=VSS
Xi_766 NOR2_X1 $PINS ZN=n_1272 A1=n_1828 A2=n_1809 VDD=VDD VSS=VSS
Xi_765 NOR2_X1 $PINS ZN=n_1271 A1=n_1828 A2=n_1810 VDD=VDD VSS=VSS
Xi_764 NOR2_X1 $PINS ZN=n_1270 A1=n_1828 A2=n_1811 VDD=VDD VSS=VSS
Xi_763 NOR2_X1 $PINS ZN=n_1269 A1=n_1828 A2=n_1812 VDD=VDD VSS=VSS
Xi_762 NOR2_X1 $PINS ZN=n_1268 A1=n_1828 A2=n_1813 VDD=VDD VSS=VSS
Xi_761 NOR2_X1 $PINS ZN=n_1267 A1=n_1828 A2=n_1814 VDD=VDD VSS=VSS
Xi_760 NOR2_X1 $PINS ZN=n_1266 A1=n_1828 A2=n_1815 VDD=VDD VSS=VSS
Xi_759 NOR2_X1 $PINS ZN=n_1265 A1=n_1828 A2=n_1816 VDD=VDD VSS=VSS
Xi_758 NOR2_X1 $PINS ZN=n_1264 A1=n_1829 A2=n_1794 VDD=VDD VSS=VSS
Xi_757 NOR2_X1 $PINS ZN=n_1263 A1=n_1829 A2=n_1795 VDD=VDD VSS=VSS
Xi_756 NOR2_X1 $PINS ZN=n_1262 A1=n_1829 A2=n_1796 VDD=VDD VSS=VSS
Xi_755 NOR2_X1 $PINS ZN=n_1261 A1=n_1829 A2=n_1797 VDD=VDD VSS=VSS
Xi_754 NOR2_X1 $PINS ZN=n_1260 A1=n_1829 A2=n_1798 VDD=VDD VSS=VSS
Xi_753 NOR2_X1 $PINS ZN=n_1259 A1=n_1829 A2=n_1799 VDD=VDD VSS=VSS
Xi_752 NOR2_X1 $PINS ZN=n_1258 A1=n_1829 A2=n_1800 VDD=VDD VSS=VSS
Xi_751 NOR2_X1 $PINS ZN=n_1257 A1=n_1829 A2=n_1801 VDD=VDD VSS=VSS
Xi_750 NOR2_X1 $PINS ZN=n_1256 A1=n_1829 A2=n_1802 VDD=VDD VSS=VSS
Xi_749 NOR2_X1 $PINS ZN=n_1255 A1=n_1829 A2=n_1803 VDD=VDD VSS=VSS
Xi_748 NOR2_X1 $PINS ZN=n_1254 A1=n_1829 A2=n_1804 VDD=VDD VSS=VSS
Xi_747 NOR2_X1 $PINS ZN=n_1253 A1=n_1829 A2=n_1805 VDD=VDD VSS=VSS
Xi_746 NOR2_X1 $PINS ZN=n_1252 A1=n_1829 A2=n_1806 VDD=VDD VSS=VSS
Xi_745 NOR2_X1 $PINS ZN=n_1251 A1=n_1829 A2=n_1807 VDD=VDD VSS=VSS
Xi_744 NOR2_X1 $PINS ZN=n_1250 A1=n_1829 A2=n_1808 VDD=VDD VSS=VSS
Xi_743 NOR2_X1 $PINS ZN=n_1249 A1=n_1829 A2=n_1809 VDD=VDD VSS=VSS
Xi_742 NOR2_X1 $PINS ZN=n_1248 A1=n_1829 A2=n_1810 VDD=VDD VSS=VSS
Xi_741 NOR2_X1 $PINS ZN=n_1247 A1=n_1829 A2=n_1811 VDD=VDD VSS=VSS
Xi_740 NOR2_X1 $PINS ZN=n_1246 A1=n_1829 A2=n_1812 VDD=VDD VSS=VSS
Xi_739 NOR2_X1 $PINS ZN=n_1245 A1=n_1829 A2=n_1813 VDD=VDD VSS=VSS
Xi_738 NOR2_X1 $PINS ZN=n_1244 A1=n_1829 A2=n_1814 VDD=VDD VSS=VSS
Xi_737 NOR2_X1 $PINS ZN=n_1243 A1=n_1829 A2=n_1815 VDD=VDD VSS=VSS
Xi_736 NOR2_X1 $PINS ZN=n_1242 A1=n_1829 A2=n_1816 VDD=VDD VSS=VSS
Xi_735 NOR2_X1 $PINS ZN=n_1241 A1=n_1830 A2=n_1794 VDD=VDD VSS=VSS
Xi_734 NOR2_X1 $PINS ZN=n_1240 A1=n_1830 A2=n_1795 VDD=VDD VSS=VSS
Xi_733 NOR2_X1 $PINS ZN=n_1239 A1=n_1830 A2=n_1796 VDD=VDD VSS=VSS
Xi_732 NOR2_X1 $PINS ZN=n_1238 A1=n_1830 A2=n_1797 VDD=VDD VSS=VSS
Xi_731 NOR2_X1 $PINS ZN=n_1237 A1=n_1830 A2=n_1798 VDD=VDD VSS=VSS
Xi_730 NOR2_X1 $PINS ZN=n_1236 A1=n_1830 A2=n_1799 VDD=VDD VSS=VSS
Xi_729 NOR2_X1 $PINS ZN=n_1235 A1=n_1830 A2=n_1800 VDD=VDD VSS=VSS
Xi_728 NOR2_X1 $PINS ZN=n_1234 A1=n_1830 A2=n_1801 VDD=VDD VSS=VSS
Xi_727 NOR2_X1 $PINS ZN=n_1233 A1=n_1830 A2=n_1802 VDD=VDD VSS=VSS
Xi_726 NOR2_X1 $PINS ZN=n_1232 A1=n_1830 A2=n_1803 VDD=VDD VSS=VSS
Xi_725 NOR2_X1 $PINS ZN=n_1231 A1=n_1830 A2=n_1804 VDD=VDD VSS=VSS
Xi_724 NOR2_X1 $PINS ZN=n_1230 A1=n_1830 A2=n_1805 VDD=VDD VSS=VSS
Xi_723 NOR2_X1 $PINS ZN=n_1229 A1=n_1830 A2=n_1806 VDD=VDD VSS=VSS
Xi_722 NOR2_X1 $PINS ZN=n_1228 A1=n_1830 A2=n_1807 VDD=VDD VSS=VSS
Xi_721 NOR2_X1 $PINS ZN=n_1227 A1=n_1830 A2=n_1808 VDD=VDD VSS=VSS
Xi_720 NOR2_X1 $PINS ZN=n_1226 A1=n_1830 A2=n_1809 VDD=VDD VSS=VSS
Xi_719 NOR2_X1 $PINS ZN=n_1225 A1=n_1830 A2=n_1810 VDD=VDD VSS=VSS
Xi_718 NOR2_X1 $PINS ZN=n_1224 A1=n_1830 A2=n_1811 VDD=VDD VSS=VSS
Xi_717 NOR2_X1 $PINS ZN=n_1223 A1=n_1830 A2=n_1812 VDD=VDD VSS=VSS
Xi_716 NOR2_X1 $PINS ZN=n_1222 A1=n_1830 A2=n_1813 VDD=VDD VSS=VSS
Xi_715 NOR2_X1 $PINS ZN=n_1221 A1=n_1830 A2=n_1814 VDD=VDD VSS=VSS
Xi_714 NOR2_X1 $PINS ZN=n_1220 A1=n_1830 A2=n_1815 VDD=VDD VSS=VSS
Xi_713 NOR2_X1 $PINS ZN=n_1219 A1=n_1830 A2=n_1816 VDD=VDD VSS=VSS
Xi_712 NOR2_X1 $PINS ZN=n_1218 A1=n_1831 A2=n_1794 VDD=VDD VSS=VSS
Xi_711 NOR2_X1 $PINS ZN=n_1217 A1=n_1831 A2=n_1795 VDD=VDD VSS=VSS
Xi_710 NOR2_X1 $PINS ZN=n_1216 A1=n_1831 A2=n_1796 VDD=VDD VSS=VSS
Xi_709 NOR2_X1 $PINS ZN=n_1215 A1=n_1831 A2=n_1797 VDD=VDD VSS=VSS
Xi_708 NOR2_X1 $PINS ZN=n_1214 A1=n_1831 A2=n_1798 VDD=VDD VSS=VSS
Xi_707 NOR2_X1 $PINS ZN=n_1213 A1=n_1831 A2=n_1799 VDD=VDD VSS=VSS
Xi_706 NOR2_X1 $PINS ZN=n_1212 A1=n_1831 A2=n_1800 VDD=VDD VSS=VSS
Xi_705 NOR2_X1 $PINS ZN=n_1211 A1=n_1831 A2=n_1801 VDD=VDD VSS=VSS
Xi_704 NOR2_X1 $PINS ZN=n_1210 A1=n_1831 A2=n_1802 VDD=VDD VSS=VSS
Xi_703 NOR2_X1 $PINS ZN=n_1209 A1=n_1831 A2=n_1803 VDD=VDD VSS=VSS
Xi_702 NOR2_X1 $PINS ZN=n_1208 A1=n_1831 A2=n_1804 VDD=VDD VSS=VSS
Xi_701 NOR2_X1 $PINS ZN=n_1207 A1=n_1831 A2=n_1805 VDD=VDD VSS=VSS
Xi_700 NOR2_X1 $PINS ZN=n_1206 A1=n_1831 A2=n_1806 VDD=VDD VSS=VSS
Xi_699 NOR2_X1 $PINS ZN=n_1205 A1=n_1831 A2=n_1807 VDD=VDD VSS=VSS
Xi_698 NOR2_X1 $PINS ZN=n_1204 A1=n_1831 A2=n_1808 VDD=VDD VSS=VSS
Xi_697 NOR2_X1 $PINS ZN=n_1203 A1=n_1831 A2=n_1809 VDD=VDD VSS=VSS
Xi_696 NOR2_X1 $PINS ZN=n_1202 A1=n_1831 A2=n_1810 VDD=VDD VSS=VSS
Xi_695 NOR2_X1 $PINS ZN=n_1201 A1=n_1831 A2=n_1811 VDD=VDD VSS=VSS
Xi_694 NOR2_X1 $PINS ZN=n_1200 A1=n_1831 A2=n_1812 VDD=VDD VSS=VSS
Xi_693 NOR2_X1 $PINS ZN=n_1199 A1=n_1831 A2=n_1813 VDD=VDD VSS=VSS
Xi_692 NOR2_X1 $PINS ZN=n_1198 A1=n_1831 A2=n_1814 VDD=VDD VSS=VSS
Xi_691 NOR2_X1 $PINS ZN=n_1197 A1=n_1831 A2=n_1815 VDD=VDD VSS=VSS
Xi_690 NOR2_X1 $PINS ZN=n_1196 A1=n_1831 A2=n_1816 VDD=VDD VSS=VSS
Xi_689 NOR2_X1 $PINS ZN=n_1195 A1=n_1832 A2=n_1794 VDD=VDD VSS=VSS
Xi_688 NOR2_X1 $PINS ZN=n_1194 A1=n_1832 A2=n_1795 VDD=VDD VSS=VSS
Xi_687 NOR2_X1 $PINS ZN=n_1193 A1=n_1832 A2=n_1796 VDD=VDD VSS=VSS
Xi_686 NOR2_X1 $PINS ZN=n_1192 A1=n_1832 A2=n_1797 VDD=VDD VSS=VSS
Xi_685 NOR2_X1 $PINS ZN=n_1191 A1=n_1832 A2=n_1798 VDD=VDD VSS=VSS
Xi_684 NOR2_X1 $PINS ZN=n_1190 A1=n_1832 A2=n_1799 VDD=VDD VSS=VSS
Xi_683 NOR2_X1 $PINS ZN=n_1189 A1=n_1832 A2=n_1800 VDD=VDD VSS=VSS
Xi_682 NOR2_X1 $PINS ZN=n_1188 A1=n_1832 A2=n_1801 VDD=VDD VSS=VSS
Xi_681 NOR2_X1 $PINS ZN=n_1187 A1=n_1832 A2=n_1802 VDD=VDD VSS=VSS
Xi_680 NOR2_X1 $PINS ZN=n_1186 A1=n_1832 A2=n_1803 VDD=VDD VSS=VSS
Xi_679 NOR2_X1 $PINS ZN=n_1185 A1=n_1832 A2=n_1804 VDD=VDD VSS=VSS
Xi_678 NOR2_X1 $PINS ZN=n_1184 A1=n_1832 A2=n_1805 VDD=VDD VSS=VSS
Xi_677 NOR2_X1 $PINS ZN=n_1183 A1=n_1832 A2=n_1806 VDD=VDD VSS=VSS
Xi_676 NOR2_X1 $PINS ZN=n_1182 A1=n_1832 A2=n_1807 VDD=VDD VSS=VSS
Xi_675 NOR2_X1 $PINS ZN=n_1181 A1=n_1832 A2=n_1808 VDD=VDD VSS=VSS
Xi_674 NOR2_X1 $PINS ZN=n_1180 A1=n_1832 A2=n_1809 VDD=VDD VSS=VSS
Xi_673 NOR2_X1 $PINS ZN=n_1179 A1=n_1832 A2=n_1810 VDD=VDD VSS=VSS
Xi_672 NOR2_X1 $PINS ZN=n_1178 A1=n_1832 A2=n_1811 VDD=VDD VSS=VSS
Xi_671 NOR2_X1 $PINS ZN=n_1177 A1=n_1832 A2=n_1812 VDD=VDD VSS=VSS
Xi_670 NOR2_X1 $PINS ZN=n_1176 A1=n_1832 A2=n_1813 VDD=VDD VSS=VSS
Xi_669 NOR2_X1 $PINS ZN=n_1175 A1=n_1832 A2=n_1814 VDD=VDD VSS=VSS
Xi_668 NOR2_X1 $PINS ZN=n_1174 A1=n_1832 A2=n_1815 VDD=VDD VSS=VSS
Xi_667 NOR2_X1 $PINS ZN=n_1173 A1=n_1832 A2=n_1816 VDD=VDD VSS=VSS
Xi_666 NOR2_X1 $PINS ZN=n_1172 A1=n_1833 A2=n_1794 VDD=VDD VSS=VSS
Xi_665 NOR2_X1 $PINS ZN=n_1171 A1=n_1833 A2=n_1795 VDD=VDD VSS=VSS
Xi_664 NOR2_X1 $PINS ZN=n_1170 A1=n_1833 A2=n_1796 VDD=VDD VSS=VSS
Xi_663 NOR2_X1 $PINS ZN=n_1169 A1=n_1833 A2=n_1797 VDD=VDD VSS=VSS
Xi_662 NOR2_X1 $PINS ZN=n_1168 A1=n_1833 A2=n_1798 VDD=VDD VSS=VSS
Xi_661 NOR2_X1 $PINS ZN=n_1167 A1=n_1833 A2=n_1799 VDD=VDD VSS=VSS
Xi_660 NOR2_X1 $PINS ZN=n_1166 A1=n_1833 A2=n_1800 VDD=VDD VSS=VSS
Xi_659 NOR2_X1 $PINS ZN=n_1165 A1=n_1833 A2=n_1801 VDD=VDD VSS=VSS
Xi_658 NOR2_X1 $PINS ZN=n_1164 A1=n_1833 A2=n_1802 VDD=VDD VSS=VSS
Xi_657 NOR2_X1 $PINS ZN=n_1163 A1=n_1833 A2=n_1803 VDD=VDD VSS=VSS
Xi_656 NOR2_X1 $PINS ZN=n_1162 A1=n_1833 A2=n_1804 VDD=VDD VSS=VSS
Xi_655 NOR2_X1 $PINS ZN=n_1161 A1=n_1833 A2=n_1805 VDD=VDD VSS=VSS
Xi_654 NOR2_X1 $PINS ZN=n_1160 A1=n_1833 A2=n_1806 VDD=VDD VSS=VSS
Xi_653 NOR2_X1 $PINS ZN=n_1159 A1=n_1833 A2=n_1807 VDD=VDD VSS=VSS
Xi_652 NOR2_X1 $PINS ZN=n_1158 A1=n_1833 A2=n_1808 VDD=VDD VSS=VSS
Xi_651 NOR2_X1 $PINS ZN=n_1157 A1=n_1833 A2=n_1809 VDD=VDD VSS=VSS
Xi_650 NOR2_X1 $PINS ZN=n_1156 A1=n_1833 A2=n_1810 VDD=VDD VSS=VSS
Xi_649 NOR2_X1 $PINS ZN=n_1155 A1=n_1833 A2=n_1811 VDD=VDD VSS=VSS
Xi_648 NOR2_X1 $PINS ZN=n_1154 A1=n_1833 A2=n_1812 VDD=VDD VSS=VSS
Xi_647 NOR2_X1 $PINS ZN=n_1153 A1=n_1833 A2=n_1813 VDD=VDD VSS=VSS
Xi_646 NOR2_X1 $PINS ZN=n_1152 A1=n_1833 A2=n_1814 VDD=VDD VSS=VSS
Xi_645 NOR2_X1 $PINS ZN=n_1151 A1=n_1833 A2=n_1815 VDD=VDD VSS=VSS
Xi_644 NOR2_X1 $PINS ZN=n_1150 A1=n_1833 A2=n_1816 VDD=VDD VSS=VSS
Xi_643 NOR2_X1 $PINS ZN=n_1149 A1=n_1834 A2=n_1794 VDD=VDD VSS=VSS
Xi_642 NOR2_X1 $PINS ZN=n_1148 A1=n_1834 A2=n_1795 VDD=VDD VSS=VSS
Xi_641 NOR2_X1 $PINS ZN=n_1147 A1=n_1834 A2=n_1796 VDD=VDD VSS=VSS
Xi_640 NOR2_X1 $PINS ZN=n_1146 A1=n_1834 A2=n_1797 VDD=VDD VSS=VSS
Xi_639 NOR2_X1 $PINS ZN=n_1145 A1=n_1834 A2=n_1798 VDD=VDD VSS=VSS
Xi_638 NOR2_X1 $PINS ZN=n_1144 A1=n_1834 A2=n_1799 VDD=VDD VSS=VSS
Xi_637 NOR2_X1 $PINS ZN=n_1143 A1=n_1834 A2=n_1800 VDD=VDD VSS=VSS
Xi_636 NOR2_X1 $PINS ZN=n_1142 A1=n_1834 A2=n_1801 VDD=VDD VSS=VSS
Xi_635 NOR2_X1 $PINS ZN=n_1141 A1=n_1834 A2=n_1802 VDD=VDD VSS=VSS
Xi_634 NOR2_X1 $PINS ZN=n_1140 A1=n_1834 A2=n_1803 VDD=VDD VSS=VSS
Xi_633 NOR2_X1 $PINS ZN=n_1139 A1=n_1834 A2=n_1804 VDD=VDD VSS=VSS
Xi_632 NOR2_X1 $PINS ZN=n_1138 A1=n_1834 A2=n_1805 VDD=VDD VSS=VSS
Xi_631 NOR2_X1 $PINS ZN=n_1137 A1=n_1834 A2=n_1806 VDD=VDD VSS=VSS
Xi_630 NOR2_X1 $PINS ZN=n_1136 A1=n_1834 A2=n_1807 VDD=VDD VSS=VSS
Xi_629 NOR2_X1 $PINS ZN=n_1135 A1=n_1834 A2=n_1808 VDD=VDD VSS=VSS
Xi_628 NOR2_X1 $PINS ZN=n_1134 A1=n_1834 A2=n_1809 VDD=VDD VSS=VSS
Xi_627 NOR2_X1 $PINS ZN=n_1133 A1=n_1834 A2=n_1810 VDD=VDD VSS=VSS
Xi_626 NOR2_X1 $PINS ZN=n_1132 A1=n_1834 A2=n_1811 VDD=VDD VSS=VSS
Xi_625 NOR2_X1 $PINS ZN=n_1131 A1=n_1834 A2=n_1812 VDD=VDD VSS=VSS
Xi_624 NOR2_X1 $PINS ZN=n_1130 A1=n_1834 A2=n_1813 VDD=VDD VSS=VSS
Xi_623 NOR2_X1 $PINS ZN=n_1129 A1=n_1834 A2=n_1814 VDD=VDD VSS=VSS
Xi_622 NOR2_X1 $PINS ZN=n_1128 A1=n_1834 A2=n_1815 VDD=VDD VSS=VSS
Xi_621 NOR2_X1 $PINS ZN=n_1127 A1=n_1834 A2=n_1816 VDD=VDD VSS=VSS
Xi_620 NOR2_X1 $PINS ZN=n_1126 A1=n_1835 A2=n_1794 VDD=VDD VSS=VSS
Xi_619 NOR2_X1 $PINS ZN=n_1125 A1=n_1835 A2=n_1795 VDD=VDD VSS=VSS
Xi_618 NOR2_X1 $PINS ZN=n_1124 A1=n_1835 A2=n_1796 VDD=VDD VSS=VSS
Xi_617 NOR2_X1 $PINS ZN=n_1123 A1=n_1835 A2=n_1797 VDD=VDD VSS=VSS
Xi_616 NOR2_X1 $PINS ZN=n_1122 A1=n_1835 A2=n_1798 VDD=VDD VSS=VSS
Xi_615 NOR2_X1 $PINS ZN=n_1121 A1=n_1835 A2=n_1799 VDD=VDD VSS=VSS
Xi_614 NOR2_X1 $PINS ZN=n_1120 A1=n_1835 A2=n_1800 VDD=VDD VSS=VSS
Xi_613 NOR2_X1 $PINS ZN=n_1119 A1=n_1835 A2=n_1801 VDD=VDD VSS=VSS
Xi_612 NOR2_X1 $PINS ZN=n_1118 A1=n_1835 A2=n_1802 VDD=VDD VSS=VSS
Xi_611 NOR2_X1 $PINS ZN=n_1117 A1=n_1835 A2=n_1803 VDD=VDD VSS=VSS
Xi_610 NOR2_X1 $PINS ZN=n_1116 A1=n_1835 A2=n_1804 VDD=VDD VSS=VSS
Xi_609 NOR2_X1 $PINS ZN=n_1115 A1=n_1835 A2=n_1805 VDD=VDD VSS=VSS
Xi_608 NOR2_X1 $PINS ZN=n_1114 A1=n_1835 A2=n_1806 VDD=VDD VSS=VSS
Xi_607 NOR2_X1 $PINS ZN=n_1113 A1=n_1835 A2=n_1807 VDD=VDD VSS=VSS
Xi_606 NOR2_X1 $PINS ZN=n_1112 A1=n_1835 A2=n_1808 VDD=VDD VSS=VSS
Xi_605 NOR2_X1 $PINS ZN=n_1111 A1=n_1835 A2=n_1809 VDD=VDD VSS=VSS
Xi_604 NOR2_X1 $PINS ZN=n_1110 A1=n_1835 A2=n_1810 VDD=VDD VSS=VSS
Xi_603 NOR2_X1 $PINS ZN=n_1109 A1=n_1835 A2=n_1811 VDD=VDD VSS=VSS
Xi_602 NOR2_X1 $PINS ZN=n_1108 A1=n_1835 A2=n_1812 VDD=VDD VSS=VSS
Xi_601 NOR2_X1 $PINS ZN=n_1107 A1=n_1835 A2=n_1813 VDD=VDD VSS=VSS
Xi_600 NOR2_X1 $PINS ZN=n_1106 A1=n_1835 A2=n_1814 VDD=VDD VSS=VSS
Xi_599 NOR2_X1 $PINS ZN=n_1105 A1=n_1835 A2=n_1815 VDD=VDD VSS=VSS
Xi_598 NOR2_X1 $PINS ZN=n_1104 A1=n_1835 A2=n_1816 VDD=VDD VSS=VSS
Xi_597 NOR2_X1 $PINS ZN=n_1103 A1=n_1836 A2=n_1794 VDD=VDD VSS=VSS
Xi_596 NOR2_X1 $PINS ZN=n_1102 A1=n_1836 A2=n_1795 VDD=VDD VSS=VSS
Xi_595 NOR2_X1 $PINS ZN=n_1101 A1=n_1836 A2=n_1796 VDD=VDD VSS=VSS
Xi_594 NOR2_X1 $PINS ZN=n_1100 A1=n_1836 A2=n_1797 VDD=VDD VSS=VSS
Xi_593 NOR2_X1 $PINS ZN=n_1099 A1=n_1836 A2=n_1798 VDD=VDD VSS=VSS
Xi_592 NOR2_X1 $PINS ZN=n_1098 A1=n_1836 A2=n_1799 VDD=VDD VSS=VSS
Xi_591 NOR2_X1 $PINS ZN=n_1097 A1=n_1836 A2=n_1800 VDD=VDD VSS=VSS
Xi_590 NOR2_X1 $PINS ZN=n_1096 A1=n_1836 A2=n_1801 VDD=VDD VSS=VSS
Xi_589 NOR2_X1 $PINS ZN=n_1095 A1=n_1836 A2=n_1802 VDD=VDD VSS=VSS
Xi_588 NOR2_X1 $PINS ZN=n_1094 A1=n_1836 A2=n_1803 VDD=VDD VSS=VSS
Xi_587 NOR2_X1 $PINS ZN=n_1093 A1=n_1836 A2=n_1804 VDD=VDD VSS=VSS
Xi_586 NOR2_X1 $PINS ZN=n_1092 A1=n_1836 A2=n_1805 VDD=VDD VSS=VSS
Xi_585 NOR2_X1 $PINS ZN=n_1091 A1=n_1836 A2=n_1806 VDD=VDD VSS=VSS
Xi_584 NOR2_X1 $PINS ZN=n_1090 A1=n_1836 A2=n_1807 VDD=VDD VSS=VSS
Xi_583 NOR2_X1 $PINS ZN=n_1089 A1=n_1836 A2=n_1808 VDD=VDD VSS=VSS
Xi_582 NOR2_X1 $PINS ZN=n_1088 A1=n_1836 A2=n_1809 VDD=VDD VSS=VSS
Xi_581 NOR2_X1 $PINS ZN=n_1087 A1=n_1836 A2=n_1810 VDD=VDD VSS=VSS
Xi_580 NOR2_X1 $PINS ZN=n_1086 A1=n_1836 A2=n_1811 VDD=VDD VSS=VSS
Xi_579 NOR2_X1 $PINS ZN=n_1085 A1=n_1836 A2=n_1812 VDD=VDD VSS=VSS
Xi_578 NOR2_X1 $PINS ZN=n_1084 A1=n_1836 A2=n_1813 VDD=VDD VSS=VSS
Xi_577 NOR2_X1 $PINS ZN=n_1083 A1=n_1836 A2=n_1814 VDD=VDD VSS=VSS
Xi_576 NOR2_X1 $PINS ZN=n_1082 A1=n_1836 A2=n_1815 VDD=VDD VSS=VSS
Xi_575 NOR2_X1 $PINS ZN=n_1081 A1=n_1836 A2=n_1816 VDD=VDD VSS=VSS
Xi_574 NOR2_X1 $PINS ZN=n_1080 A1=n_1837 A2=n_1794 VDD=VDD VSS=VSS
Xi_573 NOR2_X1 $PINS ZN=n_1079 A1=n_1837 A2=n_1795 VDD=VDD VSS=VSS
Xi_572 NOR2_X1 $PINS ZN=n_1078 A1=n_1837 A2=n_1796 VDD=VDD VSS=VSS
Xi_571 NOR2_X1 $PINS ZN=n_1077 A1=n_1837 A2=n_1797 VDD=VDD VSS=VSS
Xi_570 NOR2_X1 $PINS ZN=n_1076 A1=n_1837 A2=n_1798 VDD=VDD VSS=VSS
Xi_569 NOR2_X1 $PINS ZN=n_1075 A1=n_1837 A2=n_1799 VDD=VDD VSS=VSS
Xi_568 NOR2_X1 $PINS ZN=n_1074 A1=n_1837 A2=n_1800 VDD=VDD VSS=VSS
Xi_567 NOR2_X1 $PINS ZN=n_1073 A1=n_1837 A2=n_1801 VDD=VDD VSS=VSS
Xi_566 NOR2_X1 $PINS ZN=n_1072 A1=n_1837 A2=n_1802 VDD=VDD VSS=VSS
Xi_565 NOR2_X1 $PINS ZN=n_1071 A1=n_1837 A2=n_1803 VDD=VDD VSS=VSS
Xi_564 NOR2_X1 $PINS ZN=n_1070 A1=n_1837 A2=n_1804 VDD=VDD VSS=VSS
Xi_563 NOR2_X1 $PINS ZN=n_1069 A1=n_1837 A2=n_1805 VDD=VDD VSS=VSS
Xi_562 NOR2_X1 $PINS ZN=n_1068 A1=n_1837 A2=n_1806 VDD=VDD VSS=VSS
Xi_561 NOR2_X1 $PINS ZN=n_1067 A1=n_1837 A2=n_1807 VDD=VDD VSS=VSS
Xi_560 NOR2_X1 $PINS ZN=n_1066 A1=n_1837 A2=n_1808 VDD=VDD VSS=VSS
Xi_559 NOR2_X1 $PINS ZN=n_1065 A1=n_1837 A2=n_1809 VDD=VDD VSS=VSS
Xi_558 NOR2_X1 $PINS ZN=n_1064 A1=n_1837 A2=n_1810 VDD=VDD VSS=VSS
Xi_557 NOR2_X1 $PINS ZN=n_1063 A1=n_1837 A2=n_1811 VDD=VDD VSS=VSS
Xi_556 NOR2_X1 $PINS ZN=n_1062 A1=n_1837 A2=n_1812 VDD=VDD VSS=VSS
Xi_555 NOR2_X1 $PINS ZN=n_1061 A1=n_1837 A2=n_1813 VDD=VDD VSS=VSS
Xi_554 NOR2_X1 $PINS ZN=n_1060 A1=n_1837 A2=n_1814 VDD=VDD VSS=VSS
Xi_553 NOR2_X1 $PINS ZN=n_1059 A1=n_1837 A2=n_1815 VDD=VDD VSS=VSS
Xi_552 NOR2_X1 $PINS ZN=n_1058 A1=n_1837 A2=n_1816 VDD=VDD VSS=VSS
Xi_551 NOR2_X1 $PINS ZN=n_1057 A1=n_1838 A2=n_1794 VDD=VDD VSS=VSS
Xi_550 NOR2_X1 $PINS ZN=n_1056 A1=n_1838 A2=n_1795 VDD=VDD VSS=VSS
Xi_549 NOR2_X1 $PINS ZN=n_1055 A1=n_1838 A2=n_1796 VDD=VDD VSS=VSS
Xi_548 NOR2_X1 $PINS ZN=n_1054 A1=n_1838 A2=n_1797 VDD=VDD VSS=VSS
Xi_547 NOR2_X1 $PINS ZN=n_1053 A1=n_1838 A2=n_1798 VDD=VDD VSS=VSS
Xi_546 NOR2_X1 $PINS ZN=n_1052 A1=n_1838 A2=n_1799 VDD=VDD VSS=VSS
Xi_545 NOR2_X1 $PINS ZN=n_1051 A1=n_1838 A2=n_1800 VDD=VDD VSS=VSS
Xi_544 NOR2_X1 $PINS ZN=n_1050 A1=n_1838 A2=n_1801 VDD=VDD VSS=VSS
Xi_543 NOR2_X1 $PINS ZN=n_1049 A1=n_1838 A2=n_1802 VDD=VDD VSS=VSS
Xi_542 NOR2_X1 $PINS ZN=n_1048 A1=n_1838 A2=n_1803 VDD=VDD VSS=VSS
Xi_541 NOR2_X1 $PINS ZN=n_1047 A1=n_1838 A2=n_1804 VDD=VDD VSS=VSS
Xi_540 NOR2_X1 $PINS ZN=n_1046 A1=n_1838 A2=n_1805 VDD=VDD VSS=VSS
Xi_539 NOR2_X1 $PINS ZN=n_1045 A1=n_1838 A2=n_1806 VDD=VDD VSS=VSS
Xi_538 NOR2_X1 $PINS ZN=n_1044 A1=n_1838 A2=n_1807 VDD=VDD VSS=VSS
Xi_537 NOR2_X1 $PINS ZN=n_1043 A1=n_1838 A2=n_1808 VDD=VDD VSS=VSS
Xi_536 NOR2_X1 $PINS ZN=n_1042 A1=n_1838 A2=n_1809 VDD=VDD VSS=VSS
Xi_535 NOR2_X1 $PINS ZN=n_1041 A1=n_1838 A2=n_1810 VDD=VDD VSS=VSS
Xi_534 NOR2_X1 $PINS ZN=n_1040 A1=n_1838 A2=n_1811 VDD=VDD VSS=VSS
Xi_533 NOR2_X1 $PINS ZN=n_1039 A1=n_1838 A2=n_1812 VDD=VDD VSS=VSS
Xi_532 NOR2_X1 $PINS ZN=n_1038 A1=n_1838 A2=n_1813 VDD=VDD VSS=VSS
Xi_531 NOR2_X1 $PINS ZN=n_1037 A1=n_1838 A2=n_1814 VDD=VDD VSS=VSS
Xi_530 NOR2_X1 $PINS ZN=n_1036 A1=n_1838 A2=n_1815 VDD=VDD VSS=VSS
Xi_529 NOR2_X1 $PINS ZN=n_1035 A1=n_1838 A2=n_1816 VDD=VDD VSS=VSS
Xi_528 NOR2_X1 $PINS ZN=n_1034 A1=n_1839 A2=n_1794 VDD=VDD VSS=VSS
Xi_527 NOR2_X1 $PINS ZN=n_1033 A1=n_1839 A2=n_1795 VDD=VDD VSS=VSS
Xi_526 NOR2_X1 $PINS ZN=n_1032 A1=n_1839 A2=n_1796 VDD=VDD VSS=VSS
Xi_525 NOR2_X1 $PINS ZN=n_1031 A1=n_1839 A2=n_1797 VDD=VDD VSS=VSS
Xi_524 NOR2_X1 $PINS ZN=n_1030 A1=n_1839 A2=n_1798 VDD=VDD VSS=VSS
Xi_523 NOR2_X1 $PINS ZN=n_1029 A1=n_1839 A2=n_1799 VDD=VDD VSS=VSS
Xi_522 NOR2_X1 $PINS ZN=n_1028 A1=n_1839 A2=n_1800 VDD=VDD VSS=VSS
Xi_521 NOR2_X1 $PINS ZN=n_1027 A1=n_1839 A2=n_1801 VDD=VDD VSS=VSS
Xi_520 NOR2_X1 $PINS ZN=n_1026 A1=n_1839 A2=n_1802 VDD=VDD VSS=VSS
Xi_519 NOR2_X1 $PINS ZN=n_1025 A1=n_1839 A2=n_1803 VDD=VDD VSS=VSS
Xi_518 NOR2_X1 $PINS ZN=n_1024 A1=n_1839 A2=n_1804 VDD=VDD VSS=VSS
Xi_517 NOR2_X1 $PINS ZN=n_1023 A1=n_1839 A2=n_1805 VDD=VDD VSS=VSS
Xi_516 NOR2_X1 $PINS ZN=n_1022 A1=n_1839 A2=n_1806 VDD=VDD VSS=VSS
Xi_515 NOR2_X1 $PINS ZN=n_1021 A1=n_1839 A2=n_1807 VDD=VDD VSS=VSS
Xi_514 NOR2_X1 $PINS ZN=n_1020 A1=n_1839 A2=n_1808 VDD=VDD VSS=VSS
Xi_513 NOR2_X1 $PINS ZN=n_1019 A1=n_1839 A2=n_1809 VDD=VDD VSS=VSS
Xi_512 NOR2_X1 $PINS ZN=n_1018 A1=n_1839 A2=n_1810 VDD=VDD VSS=VSS
Xi_511 NOR2_X1 $PINS ZN=n_1017 A1=n_1839 A2=n_1811 VDD=VDD VSS=VSS
Xi_510 NOR2_X1 $PINS ZN=n_1016 A1=n_1839 A2=n_1812 VDD=VDD VSS=VSS
Xi_509 NOR2_X1 $PINS ZN=n_1015 A1=n_1839 A2=n_1813 VDD=VDD VSS=VSS
Xi_508 NOR2_X1 $PINS ZN=n_1014 A1=n_1839 A2=n_1814 VDD=VDD VSS=VSS
Xi_507 NOR2_X1 $PINS ZN=n_1013 A1=n_1839 A2=n_1815 VDD=VDD VSS=VSS
Xi_506 NOR2_X1 $PINS ZN=n_1012 A1=n_1839 A2=n_1816 VDD=VDD VSS=VSS
Xi_505 FA_X1 $PINS CO=n_1011 S=n_1010 A=a_mantissa[22] B=b_mantissa[22]
+ CI=n_1007 VDD=VDD VSS=VSS
Xi_504 FA_X1 $PINS CO=n_1009 S=n_1008 A=n_1001 B=n_1006 CI=n_1003 VDD=VDD
+ VSS=VSS
Xi_503 FA_X1 $PINS CO=n_1007 S=n_1006 A=a_mantissa[21] B=n_1012
+ CI=b_mantissa[21] VDD=VDD VSS=VSS
Xi_502 FA_X1 $PINS CO=n_1005 S=n_1004 A=n_1000 B=n_1002 CI=n_997 VDD=VDD
+ VSS=VSS
Xi_501 FA_X1 $PINS CO=n_1003 S=n_1002 A=b_mantissa[20] B=n_993 CI=n_995 VDD=VDD
+ VSS=VSS
Xi_500 FA_X1 $PINS CO=n_1001 S=n_1000 A=a_mantissa[20] B=n_1013 CI=n_1035
+ VDD=VDD VSS=VSS
Xi_499 FA_X1 $PINS CO=n_999 S=n_998 A=n_987 B=n_989 CI=n_996 VDD=VDD VSS=VSS
Xi_498 FA_X1 $PINS CO=n_997 S=n_996 A=n_983 B=n_994 CI=n_992 VDD=VDD VSS=VSS
Xi_497 FA_X1 $PINS CO=n_995 S=n_994 A=n_1058 B=b_mantissa[19] CI=n_985 VDD=VDD
+ VSS=VSS
Xi_496 FA_X1 $PINS CO=n_993 S=n_992 A=a_mantissa[19] B=n_1014 CI=n_1036 VDD=VDD
+ VSS=VSS
Xi_495 FA_X1 $PINS CO=n_991 S=n_990 A=n_977 B=n_979 CI=n_988 VDD=VDD VSS=VSS
Xi_494 FA_X1 $PINS CO=n_989 S=n_988 A=n_984 B=n_982 CI=n_986 VDD=VDD VSS=VSS
Xi_493 FA_X1 $PINS CO=n_987 S=n_986 A=n_973 B=n_971 CI=n_975 VDD=VDD VSS=VSS
Xi_492 FA_X1 $PINS CO=n_985 S=n_984 A=n_1059 B=n_1081 CI=b_mantissa[18] VDD=VDD
+ VSS=VSS
Xi_491 FA_X1 $PINS CO=n_983 S=n_982 A=a_mantissa[18] B=n_1015 CI=n_1037 VDD=VDD
+ VSS=VSS
Xi_490 FA_X1 $PINS CO=n_981 S=n_980 A=n_976 B=n_967 CI=n_978 VDD=VDD VSS=VSS
Xi_489 FA_X1 $PINS CO=n_979 S=n_978 A=n_963 B=n_974 CI=n_965 VDD=VDD VSS=VSS
Xi_488 FA_X1 $PINS CO=n_977 S=n_976 A=n_961 B=n_972 CI=n_970 VDD=VDD VSS=VSS
Xi_487 FA_X1 $PINS CO=n_975 S=n_974 A=b_mantissa[17] B=n_959 CI=n_957 VDD=VDD
+ VSS=VSS
Xi_486 FA_X1 $PINS CO=n_973 S=n_972 A=n_1060 B=n_1082 CI=n_1104 VDD=VDD VSS=VSS
Xi_485 FA_X1 $PINS CO=n_971 S=n_970 A=a_mantissa[17] B=n_1016 CI=n_1038 VDD=VDD
+ VSS=VSS
Xi_484 FA_X1 $PINS CO=n_969 S=n_968 A=n_964 B=n_966 CI=n_953 VDD=VDD VSS=VSS
Xi_483 FA_X1 $PINS CO=n_967 S=n_966 A=n_962 B=n_949 CI=n_951 VDD=VDD VSS=VSS
Xi_482 FA_X1 $PINS CO=n_965 S=n_964 A=n_960 B=n_958 CI=n_956 VDD=VDD VSS=VSS
Xi_481 FA_X1 $PINS CO=n_963 S=n_962 A=n_943 B=n_941 CI=n_947 VDD=VDD VSS=VSS
Xi_480 FA_X1 $PINS CO=n_961 S=n_960 A=n_1127 B=b_mantissa[16] CI=n_945 VDD=VDD
+ VSS=VSS
Xi_479 FA_X1 $PINS CO=n_959 S=n_958 A=n_1061 B=n_1083 CI=n_1105 VDD=VDD VSS=VSS
Xi_478 FA_X1 $PINS CO=n_957 S=n_956 A=a_mantissa[16] B=n_1017 CI=n_1039 VDD=VDD
+ VSS=VSS
Xi_477 FA_X1 $PINS CO=n_955 S=n_954 A=n_935 B=n_937 CI=n_952 VDD=VDD VSS=VSS
Xi_476 FA_X1 $PINS CO=n_953 S=n_952 A=n_933 B=n_948 CI=n_950 VDD=VDD VSS=VSS
Xi_475 FA_X1 $PINS CO=n_951 S=n_950 A=n_940 B=n_931 CI=n_946 VDD=VDD VSS=VSS
Xi_474 FA_X1 $PINS CO=n_949 S=n_948 A=n_929 B=n_944 CI=n_942 VDD=VDD VSS=VSS
Xi_473 FA_X1 $PINS CO=n_947 S=n_946 A=n_927 B=n_925 CI=n_923 VDD=VDD VSS=VSS
Xi_472 FA_X1 $PINS CO=n_945 S=n_944 A=n_1128 B=n_1150 CI=b_mantissa[15] VDD=VDD
+ VSS=VSS
Xi_471 FA_X1 $PINS CO=n_943 S=n_942 A=n_1062 B=n_1084 CI=n_1106 VDD=VDD VSS=VSS
Xi_470 FA_X1 $PINS CO=n_941 S=n_940 A=a_mantissa[15] B=n_1018 CI=n_1040 VDD=VDD
+ VSS=VSS
Xi_469 FA_X1 $PINS CO=n_939 S=n_938 A=n_934 B=n_919 CI=n_936 VDD=VDD VSS=VSS
Xi_468 FA_X1 $PINS CO=n_937 S=n_936 A=n_915 B=n_932 CI=n_917 VDD=VDD VSS=VSS
Xi_467 FA_X1 $PINS CO=n_935 S=n_934 A=n_928 B=n_913 CI=n_930 VDD=VDD VSS=VSS
Xi_466 FA_X1 $PINS CO=n_933 S=n_932 A=n_926 B=n_924 CI=n_922 VDD=VDD VSS=VSS
Xi_465 FA_X1 $PINS CO=n_931 S=n_930 A=n_903 B=n_911 CI=n_909 VDD=VDD VSS=VSS
Xi_464 FA_X1 $PINS CO=n_929 S=n_928 A=b_mantissa[14] B=n_907 CI=n_905 VDD=VDD
+ VSS=VSS
Xi_463 FA_X1 $PINS CO=n_927 S=n_926 A=n_1129 B=n_1151 CI=n_1173 VDD=VDD VSS=VSS
Xi_462 FA_X1 $PINS CO=n_925 S=n_924 A=n_1063 B=n_1085 CI=n_1107 VDD=VDD VSS=VSS
Xi_461 FA_X1 $PINS CO=n_923 S=n_922 A=a_mantissa[14] B=n_1019 CI=n_1041 VDD=VDD
+ VSS=VSS
Xi_460 FA_X1 $PINS CO=n_921 S=n_920 A=n_916 B=n_899 CI=n_918 VDD=VDD VSS=VSS
Xi_459 FA_X1 $PINS CO=n_919 S=n_918 A=n_914 B=n_912 CI=n_897 VDD=VDD VSS=VSS
Xi_458 FA_X1 $PINS CO=n_917 S=n_916 A=n_893 B=n_891 CI=n_895 VDD=VDD VSS=VSS
Xi_457 FA_X1 $PINS CO=n_915 S=n_914 A=n_904 B=n_902 CI=n_910 VDD=VDD VSS=VSS
Xi_456 FA_X1 $PINS CO=n_913 S=n_912 A=n_889 B=n_908 CI=n_906 VDD=VDD VSS=VSS
Xi_455 FA_X1 $PINS CO=n_911 S=n_910 A=n_885 B=n_883 CI=n_881 VDD=VDD VSS=VSS
Xi_454 FA_X1 $PINS CO=n_909 S=n_908 A=n_1196 B=b_mantissa[13] CI=n_887 VDD=VDD
+ VSS=VSS
Xi_453 FA_X1 $PINS CO=n_907 S=n_906 A=n_1130 B=n_1152 CI=n_1174 VDD=VDD VSS=VSS
Xi_452 FA_X1 $PINS CO=n_905 S=n_904 A=n_1064 B=n_1086 CI=n_1108 VDD=VDD VSS=VSS
Xi_451 FA_X1 $PINS CO=n_903 S=n_902 A=a_mantissa[13] B=n_1020 CI=n_1042 VDD=VDD
+ VSS=VSS
Xi_450 FA_X1 $PINS CO=n_901 S=n_900 A=n_896 B=n_877 CI=n_898 VDD=VDD VSS=VSS
Xi_449 FA_X1 $PINS CO=n_899 S=n_898 A=n_892 B=n_894 CI=n_875 VDD=VDD VSS=VSS
Xi_448 FA_X1 $PINS CO=n_897 S=n_896 A=n_890 B=n_873 CI=n_871 VDD=VDD VSS=VSS
Xi_447 FA_X1 $PINS CO=n_895 S=n_894 A=n_867 B=n_888 CI=n_869 VDD=VDD VSS=VSS
Xi_446 FA_X1 $PINS CO=n_893 S=n_892 A=n_884 B=n_882 CI=n_880 VDD=VDD VSS=VSS
Xi_445 FA_X1 $PINS CO=n_891 S=n_890 A=n_857 B=n_865 CI=n_886 VDD=VDD VSS=VSS
Xi_444 FA_X1 $PINS CO=n_889 S=n_888 A=n_863 B=n_861 CI=n_859 VDD=VDD VSS=VSS
Xi_443 FA_X1 $PINS CO=n_887 S=n_886 A=n_1197 B=n_1219 CI=b_mantissa[12] VDD=VDD
+ VSS=VSS
Xi_442 FA_X1 $PINS CO=n_885 S=n_884 A=n_1131 B=n_1153 CI=n_1175 VDD=VDD VSS=VSS
Xi_441 FA_X1 $PINS CO=n_883 S=n_882 A=n_1065 B=n_1087 CI=n_1109 VDD=VDD VSS=VSS
Xi_440 FA_X1 $PINS CO=n_881 S=n_880 A=a_mantissa[12] B=n_1021 CI=n_1043 VDD=VDD
+ VSS=VSS
Xi_439 FA_X1 $PINS CO=n_879 S=n_878 A=n_853 B=n_874 CI=n_876 VDD=VDD VSS=VSS
Xi_438 FA_X1 $PINS CO=n_877 S=n_876 A=n_849 B=n_872 CI=n_851 VDD=VDD VSS=VSS
Xi_437 FA_X1 $PINS CO=n_875 S=n_874 A=n_847 B=n_870 CI=n_868 VDD=VDD VSS=VSS
Xi_436 FA_X1 $PINS CO=n_873 S=n_872 A=n_864 B=n_845 CI=n_843 VDD=VDD VSS=VSS
Xi_435 FA_X1 $PINS CO=n_871 S=n_870 A=n_858 B=n_856 CI=n_866 VDD=VDD VSS=VSS
Xi_434 FA_X1 $PINS CO=n_869 S=n_868 A=n_839 B=n_862 CI=n_860 VDD=VDD VSS=VSS
Xi_433 FA_X1 $PINS CO=n_867 S=n_866 A=n_833 B=n_831 CI=n_841 VDD=VDD VSS=VSS
Xi_432 FA_X1 $PINS CO=n_865 S=n_864 A=b_mantissa[11] B=n_837 CI=n_835 VDD=VDD
+ VSS=VSS
Xi_431 FA_X1 $PINS CO=n_863 S=n_862 A=n_1198 B=n_1220 CI=n_1242 VDD=VDD VSS=VSS
Xi_430 FA_X1 $PINS CO=n_861 S=n_860 A=n_1132 B=n_1154 CI=n_1176 VDD=VDD VSS=VSS
Xi_429 FA_X1 $PINS CO=n_859 S=n_858 A=n_1066 B=n_1088 CI=n_1110 VDD=VDD VSS=VSS
Xi_428 FA_X1 $PINS CO=n_857 S=n_856 A=a_mantissa[11] B=n_1022 CI=n_1044 VDD=VDD
+ VSS=VSS
Xi_427 FA_X1 $PINS CO=n_855 S=n_854 A=n_850 B=n_827 CI=n_852 VDD=VDD VSS=VSS
Xi_426 FA_X1 $PINS CO=n_853 S=n_852 A=n_823 B=n_848 CI=n_825 VDD=VDD VSS=VSS
Xi_425 FA_X1 $PINS CO=n_851 S=n_850 A=n_821 B=n_844 CI=n_846 VDD=VDD VSS=VSS
Xi_424 FA_X1 $PINS CO=n_849 S=n_848 A=n_819 B=n_817 CI=n_842 VDD=VDD VSS=VSS
Xi_423 FA_X1 $PINS CO=n_847 S=n_846 A=n_830 B=n_815 CI=n_840 VDD=VDD VSS=VSS
Xi_422 FA_X1 $PINS CO=n_845 S=n_844 A=n_836 B=n_834 CI=n_832 VDD=VDD VSS=VSS
Xi_421 FA_X1 $PINS CO=n_843 S=n_842 A=n_803 B=n_813 CI=n_838 VDD=VDD VSS=VSS
Xi_420 FA_X1 $PINS CO=n_841 S=n_840 A=n_809 B=n_807 CI=n_805 VDD=VDD VSS=VSS
Xi_419 FA_X1 $PINS CO=n_839 S=n_838 A=n_1265 B=b_mantissa[10] CI=n_811 VDD=VDD
+ VSS=VSS
Xi_418 FA_X1 $PINS CO=n_837 S=n_836 A=n_1199 B=n_1221 CI=n_1243 VDD=VDD VSS=VSS
Xi_417 FA_X1 $PINS CO=n_835 S=n_834 A=n_1133 B=n_1155 CI=n_1177 VDD=VDD VSS=VSS
Xi_416 FA_X1 $PINS CO=n_833 S=n_832 A=n_1067 B=n_1089 CI=n_1111 VDD=VDD VSS=VSS
Xi_415 FA_X1 $PINS CO=n_831 S=n_830 A=a_mantissa[10] B=n_1023 CI=n_1045 VDD=VDD
+ VSS=VSS
Xi_414 FA_X1 $PINS CO=n_829 S=n_828 A=n_824 B=n_799 CI=n_826 VDD=VDD VSS=VSS
Xi_413 FA_X1 $PINS CO=n_827 S=n_826 A=n_820 B=n_822 CI=n_797 VDD=VDD VSS=VSS
Xi_412 FA_X1 $PINS CO=n_825 S=n_824 A=n_818 B=n_816 CI=n_795 VDD=VDD VSS=VSS
Xi_411 FA_X1 $PINS CO=n_823 S=n_822 A=n_787 B=n_793 CI=n_791 VDD=VDD VSS=VSS
Xi_410 FA_X1 $PINS CO=n_821 S=n_820 A=n_814 B=n_812 CI=n_789 VDD=VDD VSS=VSS
Xi_409 FA_X1 $PINS CO=n_819 S=n_818 A=n_806 B=n_804 CI=n_802 VDD=VDD VSS=VSS
Xi_408 FA_X1 $PINS CO=n_817 S=n_816 A=n_783 B=n_810 CI=n_808 VDD=VDD VSS=VSS
Xi_407 FA_X1 $PINS CO=n_815 S=n_814 A=n_775 B=n_773 CI=n_785 VDD=VDD VSS=VSS
Xi_406 FA_X1 $PINS CO=n_813 S=n_812 A=n_781 B=n_779 CI=n_777 VDD=VDD VSS=VSS
Xi_405 FA_X1 $PINS CO=n_811 S=n_810 A=n_1266 B=n_1288 CI=b_mantissa[9] VDD=VDD
+ VSS=VSS
Xi_404 FA_X1 $PINS CO=n_809 S=n_808 A=n_1200 B=n_1222 CI=n_1244 VDD=VDD VSS=VSS
Xi_403 FA_X1 $PINS CO=n_807 S=n_806 A=n_1134 B=n_1156 CI=n_1178 VDD=VDD VSS=VSS
Xi_402 FA_X1 $PINS CO=n_805 S=n_804 A=n_1068 B=n_1090 CI=n_1112 VDD=VDD VSS=VSS
Xi_401 FA_X1 $PINS CO=n_803 S=n_802 A=a_mantissa[9] B=n_1024 CI=n_1046 VDD=VDD
+ VSS=VSS
Xi_400 FA_X1 $PINS CO=n_801 S=n_800 A=n_796 B=n_769 CI=n_798 VDD=VDD VSS=VSS
Xi_399 FA_X1 $PINS CO=n_799 S=n_798 A=n_765 B=n_794 CI=n_767 VDD=VDD VSS=VSS
Xi_398 FA_X1 $PINS CO=n_797 S=n_796 A=n_788 B=n_790 CI=n_792 VDD=VDD VSS=VSS
Xi_397 FA_X1 $PINS CO=n_795 S=n_794 A=n_786 B=n_761 CI=n_763 VDD=VDD VSS=VSS
Xi_396 FA_X1 $PINS CO=n_793 S=n_792 A=n_782 B=n_759 CI=n_757 VDD=VDD VSS=VSS
Xi_395 FA_X1 $PINS CO=n_791 S=n_790 A=n_772 B=n_755 CI=n_784 VDD=VDD VSS=VSS
Xi_394 FA_X1 $PINS CO=n_789 S=n_788 A=n_778 B=n_776 CI=n_774 VDD=VDD VSS=VSS
Xi_393 FA_X1 $PINS CO=n_787 S=n_786 A=n_753 B=n_751 CI=n_780 VDD=VDD VSS=VSS
Xi_392 FA_X1 $PINS CO=n_785 S=n_784 A=n_745 B=n_743 CI=n_741 VDD=VDD VSS=VSS
Xi_391 FA_X1 $PINS CO=n_783 S=n_782 A=b_mantissa[8] B=n_749 CI=n_747 VDD=VDD
+ VSS=VSS
Xi_390 FA_X1 $PINS CO=n_781 S=n_780 A=n_1267 B=n_1289 CI=n_1311 VDD=VDD VSS=VSS
Xi_389 FA_X1 $PINS CO=n_779 S=n_778 A=n_1201 B=n_1223 CI=n_1245 VDD=VDD VSS=VSS
Xi_388 FA_X1 $PINS CO=n_777 S=n_776 A=n_1135 B=n_1157 CI=n_1179 VDD=VDD VSS=VSS
Xi_387 FA_X1 $PINS CO=n_775 S=n_774 A=n_1069 B=n_1091 CI=n_1113 VDD=VDD VSS=VSS
Xi_386 FA_X1 $PINS CO=n_773 S=n_772 A=a_mantissa[8] B=n_1025 CI=n_1047 VDD=VDD
+ VSS=VSS
Xi_385 FA_X1 $PINS CO=n_771 S=n_770 A=n_766 B=n_737 CI=n_768 VDD=VDD VSS=VSS
Xi_384 FA_X1 $PINS CO=n_769 S=n_768 A=n_733 B=n_764 CI=n_735 VDD=VDD VSS=VSS
Xi_383 FA_X1 $PINS CO=n_767 S=n_766 A=n_731 B=n_762 CI=n_760 VDD=VDD VSS=VSS
Xi_382 FA_X1 $PINS CO=n_765 S=n_764 A=n_729 B=n_758 CI=n_756 VDD=VDD VSS=VSS
Xi_381 FA_X1 $PINS CO=n_763 S=n_762 A=n_725 B=n_723 CI=n_727 VDD=VDD VSS=VSS
Xi_380 FA_X1 $PINS CO=n_761 S=n_760 A=n_740 B=n_754 CI=n_752 VDD=VDD VSS=VSS
Xi_379 FA_X1 $PINS CO=n_759 S=n_758 A=n_746 B=n_744 CI=n_742 VDD=VDD VSS=VSS
Xi_378 FA_X1 $PINS CO=n_757 S=n_756 A=n_719 B=n_750 CI=n_748 VDD=VDD VSS=VSS
Xi_377 FA_X1 $PINS CO=n_755 S=n_754 A=n_709 B=n_707 CI=n_721 VDD=VDD VSS=VSS
Xi_376 FA_X1 $PINS CO=n_753 S=n_752 A=n_715 B=n_713 CI=n_711 VDD=VDD VSS=VSS
Xi_375 FA_X1 $PINS CO=n_751 S=n_750 A=n_1334 B=b_mantissa[7] CI=n_717 VDD=VDD
+ VSS=VSS
Xi_374 FA_X1 $PINS CO=n_749 S=n_748 A=n_1268 B=n_1290 CI=n_1312 VDD=VDD VSS=VSS
Xi_373 FA_X1 $PINS CO=n_747 S=n_746 A=n_1202 B=n_1224 CI=n_1246 VDD=VDD VSS=VSS
Xi_372 FA_X1 $PINS CO=n_745 S=n_744 A=n_1136 B=n_1158 CI=n_1180 VDD=VDD VSS=VSS
Xi_371 FA_X1 $PINS CO=n_743 S=n_742 A=n_1070 B=n_1092 CI=n_1114 VDD=VDD VSS=VSS
Xi_370 FA_X1 $PINS CO=n_741 S=n_740 A=a_mantissa[7] B=n_1026 CI=n_1048 VDD=VDD
+ VSS=VSS
Xi_369 FA_X1 $PINS CO=n_739 S=n_738 A=n_734 B=n_703 CI=n_736 VDD=VDD VSS=VSS
Xi_368 FA_X1 $PINS CO=n_737 S=n_736 A=n_699 B=n_732 CI=n_701 VDD=VDD VSS=VSS
Xi_367 FA_X1 $PINS CO=n_735 S=n_734 A=n_728 B=n_697 CI=n_730 VDD=VDD VSS=VSS
Xi_366 FA_X1 $PINS CO=n_733 S=n_732 A=n_693 B=n_726 CI=n_724 VDD=VDD VSS=VSS
Xi_365 FA_X1 $PINS CO=n_731 S=n_730 A=n_689 B=n_722 CI=n_695 VDD=VDD VSS=VSS
Xi_364 FA_X1 $PINS CO=n_729 S=n_728 A=n_720 B=n_718 CI=n_691 VDD=VDD VSS=VSS
Xi_363 FA_X1 $PINS CO=n_727 S=n_726 A=n_708 B=n_706 CI=n_687 VDD=VDD VSS=VSS
Xi_362 FA_X1 $PINS CO=n_725 S=n_724 A=n_714 B=n_712 CI=n_710 VDD=VDD VSS=VSS
Xi_361 FA_X1 $PINS CO=n_723 S=n_722 A=n_685 B=n_683 CI=n_716 VDD=VDD VSS=VSS
Xi_360 FA_X1 $PINS CO=n_721 S=n_720 A=n_675 B=n_673 CI=n_671 VDD=VDD VSS=VSS
Xi_359 FA_X1 $PINS CO=n_719 S=n_718 A=n_681 B=n_679 CI=n_677 VDD=VDD VSS=VSS
Xi_358 FA_X1 $PINS CO=n_717 S=n_716 A=n_1335 B=n_1357 CI=b_mantissa[6] VDD=VDD
+ VSS=VSS
Xi_357 FA_X1 $PINS CO=n_715 S=n_714 A=n_1269 B=n_1291 CI=n_1313 VDD=VDD VSS=VSS
Xi_356 FA_X1 $PINS CO=n_713 S=n_712 A=n_1203 B=n_1225 CI=n_1247 VDD=VDD VSS=VSS
Xi_355 FA_X1 $PINS CO=n_711 S=n_710 A=n_1137 B=n_1159 CI=n_1181 VDD=VDD VSS=VSS
Xi_354 FA_X1 $PINS CO=n_709 S=n_708 A=n_1071 B=n_1093 CI=n_1115 VDD=VDD VSS=VSS
Xi_353 FA_X1 $PINS CO=n_707 S=n_706 A=a_mantissa[6] B=n_1027 CI=n_1049 VDD=VDD
+ VSS=VSS
Xi_352 FA_X1 $PINS CO=n_705 S=n_704 A=n_700 B=n_667 CI=n_702 VDD=VDD VSS=VSS
Xi_351 FA_X1 $PINS CO=n_703 S=n_702 A=n_663 B=n_698 CI=n_665 VDD=VDD VSS=VSS
Xi_350 FA_X1 $PINS CO=n_701 S=n_700 A=n_692 B=n_661 CI=n_696 VDD=VDD VSS=VSS
Xi_349 FA_X1 $PINS CO=n_699 S=n_698 A=n_688 B=n_659 CI=n_694 VDD=VDD VSS=VSS
Xi_348 FA_X1 $PINS CO=n_697 S=n_696 A=n_686 B=n_657 CI=n_690 VDD=VDD VSS=VSS
Xi_347 FA_X1 $PINS CO=n_695 S=n_694 A=n_655 B=n_653 CI=n_651 VDD=VDD VSS=VSS
Xi_346 FA_X1 $PINS CO=n_693 S=n_692 A=n_670 B=n_684 CI=n_682 VDD=VDD VSS=VSS
Xi_345 FA_X1 $PINS CO=n_691 S=n_690 A=n_676 B=n_674 CI=n_672 VDD=VDD VSS=VSS
Xi_344 FA_X1 $PINS CO=n_689 S=n_688 A=n_645 B=n_680 CI=n_678 VDD=VDD VSS=VSS
Xi_343 FA_X1 $PINS CO=n_687 S=n_686 A=n_633 B=n_649 CI=n_647 VDD=VDD VSS=VSS
Xi_342 FA_X1 $PINS CO=n_685 S=n_684 A=n_639 B=n_637 CI=n_635 VDD=VDD VSS=VSS
Xi_341 FA_X1 $PINS CO=n_683 S=n_682 A=b_mantissa[5] B=n_643 CI=n_641 VDD=VDD
+ VSS=VSS
Xi_340 FA_X1 $PINS CO=n_681 S=n_680 A=n_1336 B=n_1358 CI=n_1380 VDD=VDD VSS=VSS
Xi_339 FA_X1 $PINS CO=n_679 S=n_678 A=n_1270 B=n_1292 CI=n_1314 VDD=VDD VSS=VSS
Xi_338 FA_X1 $PINS CO=n_677 S=n_676 A=n_1204 B=n_1226 CI=n_1248 VDD=VDD VSS=VSS
Xi_337 FA_X1 $PINS CO=n_675 S=n_674 A=n_1138 B=n_1160 CI=n_1182 VDD=VDD VSS=VSS
Xi_336 FA_X1 $PINS CO=n_673 S=n_672 A=n_1072 B=n_1094 CI=n_1116 VDD=VDD VSS=VSS
Xi_335 FA_X1 $PINS CO=n_671 S=n_670 A=a_mantissa[5] B=n_1028 CI=n_1050 VDD=VDD
+ VSS=VSS
Xi_334 FA_X1 $PINS CO=n_669 S=n_668 A=n_664 B=n_629 CI=n_666 VDD=VDD VSS=VSS
Xi_333 FA_X1 $PINS CO=n_667 S=n_666 A=n_625 B=n_662 CI=n_627 VDD=VDD VSS=VSS
Xi_332 FA_X1 $PINS CO=n_665 S=n_664 A=n_656 B=n_623 CI=n_660 VDD=VDD VSS=VSS
Xi_331 FA_X1 $PINS CO=n_663 S=n_662 A=n_652 B=n_621 CI=n_658 VDD=VDD VSS=VSS
Xi_330 FA_X1 $PINS CO=n_661 S=n_660 A=n_619 B=n_617 CI=n_654 VDD=VDD VSS=VSS
Xi_329 FA_X1 $PINS CO=n_659 S=n_658 A=n_615 B=n_613 CI=n_650 VDD=VDD VSS=VSS
Xi_328 FA_X1 $PINS CO=n_657 S=n_656 A=n_611 B=n_648 CI=n_646 VDD=VDD VSS=VSS
Xi_327 FA_X1 $PINS CO=n_655 S=n_654 A=n_636 B=n_634 CI=n_632 VDD=VDD VSS=VSS
Xi_326 FA_X1 $PINS CO=n_653 S=n_652 A=n_642 B=n_640 CI=n_638 VDD=VDD VSS=VSS
Xi_325 FA_X1 $PINS CO=n_651 S=n_650 A=n_609 B=n_607 CI=n_644 VDD=VDD VSS=VSS
Xi_324 FA_X1 $PINS CO=n_649 S=n_648 A=n_597 B=n_595 CI=n_593 VDD=VDD VSS=VSS
Xi_323 FA_X1 $PINS CO=n_647 S=n_646 A=n_603 B=n_601 CI=n_599 VDD=VDD VSS=VSS
Xi_322 FA_X1 $PINS CO=n_645 S=n_644 A=n_1403 B=b_mantissa[4] CI=n_605 VDD=VDD
+ VSS=VSS
Xi_321 FA_X1 $PINS CO=n_643 S=n_642 A=n_1337 B=n_1359 CI=n_1381 VDD=VDD VSS=VSS
Xi_320 FA_X1 $PINS CO=n_641 S=n_640 A=n_1271 B=n_1293 CI=n_1315 VDD=VDD VSS=VSS
Xi_319 FA_X1 $PINS CO=n_639 S=n_638 A=n_1205 B=n_1227 CI=n_1249 VDD=VDD VSS=VSS
Xi_318 FA_X1 $PINS CO=n_637 S=n_636 A=n_1139 B=n_1161 CI=n_1183 VDD=VDD VSS=VSS
Xi_317 FA_X1 $PINS CO=n_635 S=n_634 A=n_1073 B=n_1095 CI=n_1117 VDD=VDD VSS=VSS
Xi_316 FA_X1 $PINS CO=n_633 S=n_632 A=a_mantissa[4] B=n_1029 CI=n_1051 VDD=VDD
+ VSS=VSS
Xi_315 FA_X1 $PINS CO=n_631 S=n_630 A=n_626 B=n_589 CI=n_628 VDD=VDD VSS=VSS
Xi_314 FA_X1 $PINS CO=n_629 S=n_628 A=n_622 B=n_624 CI=n_587 VDD=VDD VSS=VSS
Xi_313 FA_X1 $PINS CO=n_627 S=n_626 A=n_583 B=n_620 CI=n_585 VDD=VDD VSS=VSS
Xi_312 FA_X1 $PINS CO=n_625 S=n_624 A=n_616 B=n_581 CI=n_618 VDD=VDD VSS=VSS
Xi_311 FA_X1 $PINS CO=n_623 S=n_622 A=n_577 B=n_614 CI=n_612 VDD=VDD VSS=VSS
Xi_310 FA_X1 $PINS CO=n_621 S=n_620 A=n_571 B=n_610 CI=n_579 VDD=VDD VSS=VSS
Xi_309 FA_X1 $PINS CO=n_619 S=n_618 A=n_606 B=n_575 CI=n_573 VDD=VDD VSS=VSS
Xi_308 FA_X1 $PINS CO=n_617 S=n_616 A=n_592 B=n_569 CI=n_608 VDD=VDD VSS=VSS
Xi_307 FA_X1 $PINS CO=n_615 S=n_614 A=n_598 B=n_596 CI=n_594 VDD=VDD VSS=VSS
Xi_306 FA_X1 $PINS CO=n_613 S=n_612 A=n_604 B=n_602 CI=n_600 VDD=VDD VSS=VSS
Xi_305 FA_X1 $PINS CO=n_611 S=n_610 A=n_551 B=n_567 CI=n_565 VDD=VDD VSS=VSS
Xi_304 FA_X1 $PINS CO=n_609 S=n_608 A=n_557 B=n_555 CI=n_553 VDD=VDD VSS=VSS
Xi_303 FA_X1 $PINS CO=n_607 S=n_606 A=n_563 B=n_561 CI=n_559 VDD=VDD VSS=VSS
Xi_302 FA_X1 $PINS CO=n_605 S=n_604 A=n_1404 B=n_1426 CI=b_mantissa[3] VDD=VDD
+ VSS=VSS
Xi_301 FA_X1 $PINS CO=n_603 S=n_602 A=n_1338 B=n_1360 CI=n_1382 VDD=VDD VSS=VSS
Xi_300 FA_X1 $PINS CO=n_601 S=n_600 A=n_1272 B=n_1294 CI=n_1316 VDD=VDD VSS=VSS
Xi_299 FA_X1 $PINS CO=n_599 S=n_598 A=n_1206 B=n_1228 CI=n_1250 VDD=VDD VSS=VSS
Xi_298 FA_X1 $PINS CO=n_597 S=n_596 A=n_1140 B=n_1162 CI=n_1184 VDD=VDD VSS=VSS
Xi_297 FA_X1 $PINS CO=n_595 S=n_594 A=n_1074 B=n_1096 CI=n_1118 VDD=VDD VSS=VSS
Xi_296 FA_X1 $PINS CO=n_593 S=n_592 A=a_mantissa[3] B=n_1030 CI=n_1052 VDD=VDD
+ VSS=VSS
Xi_295 FA_X1 $PINS CO=n_591 S=n_590 A=n_586 B=n_588 CI=n_547 VDD=VDD VSS=VSS
Xi_294 FA_X1 $PINS CO=n_589 S=n_588 A=n_582 B=n_584 CI=n_545 VDD=VDD VSS=VSS
Xi_293 FA_X1 $PINS CO=n_587 S=n_586 A=n_580 B=n_541 CI=n_543 VDD=VDD VSS=VSS
Xi_292 FA_X1 $PINS CO=n_585 S=n_584 A=n_578 B=n_576 CI=n_539 VDD=VDD VSS=VSS
Xi_291 FA_X1 $PINS CO=n_583 S=n_582 A=n_574 B=n_572 CI=n_537 VDD=VDD VSS=VSS
Xi_290 FA_X1 $PINS CO=n_581 S=n_580 A=n_533 B=n_570 CI=n_535 VDD=VDD VSS=VSS
Xi_289 FA_X1 $PINS CO=n_579 S=n_578 A=n_564 B=n_531 CI=n_529 VDD=VDD VSS=VSS
Xi_288 FA_X1 $PINS CO=n_577 S=n_576 A=n_527 B=n_568 CI=n_566 VDD=VDD VSS=VSS
Xi_287 FA_X1 $PINS CO=n_575 S=n_574 A=n_554 B=n_552 CI=n_550 VDD=VDD VSS=VSS
Xi_286 FA_X1 $PINS CO=n_573 S=n_572 A=n_560 B=n_558 CI=n_556 VDD=VDD VSS=VSS
Xi_285 FA_X1 $PINS CO=n_571 S=n_570 A=n_523 B=n_521 CI=n_562 VDD=VDD VSS=VSS
Xi_284 FA_X1 $PINS CO=n_569 S=n_568 A=n_509 B=n_507 CI=n_525 VDD=VDD VSS=VSS
Xi_283 FA_X1 $PINS CO=n_567 S=n_566 A=n_515 B=n_513 CI=n_511 VDD=VDD VSS=VSS
Xi_282 FA_X1 $PINS CO=n_565 S=n_564 A=b_mantissa[2] B=n_519 CI=n_517 VDD=VDD
+ VSS=VSS
Xi_281 FA_X1 $PINS CO=n_563 S=n_562 A=n_1405 B=n_1427 CI=n_1449 VDD=VDD VSS=VSS
Xi_280 FA_X1 $PINS CO=n_561 S=n_560 A=n_1339 B=n_1361 CI=n_1383 VDD=VDD VSS=VSS
Xi_279 FA_X1 $PINS CO=n_559 S=n_558 A=n_1273 B=n_1295 CI=n_1317 VDD=VDD VSS=VSS
Xi_278 FA_X1 $PINS CO=n_557 S=n_556 A=n_1207 B=n_1229 CI=n_1251 VDD=VDD VSS=VSS
Xi_277 FA_X1 $PINS CO=n_555 S=n_554 A=n_1141 B=n_1163 CI=n_1185 VDD=VDD VSS=VSS
Xi_276 FA_X1 $PINS CO=n_553 S=n_552 A=n_1075 B=n_1097 CI=n_1119 VDD=VDD VSS=VSS
Xi_275 FA_X1 $PINS CO=n_551 S=n_550 A=a_mantissa[2] B=n_1031 CI=n_1053 VDD=VDD
+ VSS=VSS
Xi_274 HA_X1 $PINS CO=n_549 S=n_548 A=n_503 B=n_546 VDD=VDD VSS=VSS
Xi_273 FA_X1 $PINS CO=n_547 S=n_546 A=n_542 B=n_501 CI=n_544 VDD=VDD VSS=VSS
Xi_272 FA_X1 $PINS CO=n_545 S=n_544 A=n_499 B=n_538 CI=n_540 VDD=VDD VSS=VSS
Xi_271 FA_X1 $PINS CO=n_543 S=n_542 A=n_534 B=n_495 CI=n_497 VDD=VDD VSS=VSS
Xi_270 FA_X1 $PINS CO=n_541 S=n_540 A=n_528 B=n_493 CI=n_536 VDD=VDD VSS=VSS
Xi_269 FA_X1 $PINS CO=n_539 S=n_538 A=n_491 B=n_532 CI=n_530 VDD=VDD VSS=VSS
Xi_268 FA_X1 $PINS CO=n_537 S=n_536 A=n_487 B=n_485 CI=n_526 VDD=VDD VSS=VSS
Xi_267 FA_X1 $PINS CO=n_535 S=n_534 A=n_524 B=n_522 CI=n_489 VDD=VDD VSS=VSS
Xi_266 FA_X1 $PINS CO=n_533 S=n_532 A=n_508 B=n_506 CI=n_483 VDD=VDD VSS=VSS
Xi_265 FA_X1 $PINS CO=n_531 S=n_530 A=n_514 B=n_512 CI=n_510 VDD=VDD VSS=VSS
Xi_264 FA_X1 $PINS CO=n_529 S=n_528 A=n_520 B=n_518 CI=n_516 VDD=VDD VSS=VSS
Xi_263 FA_X1 $PINS CO=n_527 S=n_526 A=n_463 B=n_481 CI=n_479 VDD=VDD VSS=VSS
Xi_262 FA_X1 $PINS CO=n_525 S=n_524 A=n_469 B=n_467 CI=n_465 VDD=VDD VSS=VSS
Xi_261 FA_X1 $PINS CO=n_523 S=n_522 A=n_475 B=n_473 CI=n_471 VDD=VDD VSS=VSS
Xi_260 FA_X1 $PINS CO=n_521 S=n_520 A=n_1472 B=b_mantissa[1] CI=n_477 VDD=VDD
+ VSS=VSS
Xi_259 FA_X1 $PINS CO=n_519 S=n_518 A=n_1406 B=n_1428 CI=n_1450 VDD=VDD VSS=VSS
Xi_258 FA_X1 $PINS CO=n_517 S=n_516 A=n_1340 B=n_1362 CI=n_1384 VDD=VDD VSS=VSS
Xi_257 FA_X1 $PINS CO=n_515 S=n_514 A=n_1274 B=n_1296 CI=n_1318 VDD=VDD VSS=VSS
Xi_256 FA_X1 $PINS CO=n_513 S=n_512 A=n_1208 B=n_1230 CI=n_1252 VDD=VDD VSS=VSS
Xi_255 FA_X1 $PINS CO=n_511 S=n_510 A=n_1142 B=n_1164 CI=n_1186 VDD=VDD VSS=VSS
Xi_254 FA_X1 $PINS CO=n_509 S=n_508 A=n_1076 B=n_1098 CI=n_1120 VDD=VDD VSS=VSS
Xi_253 FA_X1 $PINS CO=n_507 S=n_506 A=a_mantissa[1] B=n_1032 CI=n_1054 VDD=VDD
+ VSS=VSS
Xi_252 HA_X1 $PINS CO=n_505 S=n_504 A=n_459 B=n_502 VDD=VDD VSS=VSS
Xi_251 FA_X1 $PINS CO=n_503 S=n_502 A=n_498 B=n_457 CI=n_500 VDD=VDD VSS=VSS
Xi_250 FA_X1 $PINS CO=n_501 S=n_500 A=n_494 B=n_455 CI=n_496 VDD=VDD VSS=VSS
Xi_249 FA_X1 $PINS CO=n_499 S=n_498 A=n_492 B=n_490 CI=n_453 VDD=VDD VSS=VSS
Xi_248 FA_X1 $PINS CO=n_497 S=n_496 A=n_486 B=n_484 CI=n_451 VDD=VDD VSS=VSS
Xi_247 FA_X1 $PINS CO=n_495 S=n_494 A=n_449 B=n_447 CI=n_488 VDD=VDD VSS=VSS
Xi_246 FA_X1 $PINS CO=n_493 S=n_492 A=n_443 B=n_441 CI=n_482 VDD=VDD VSS=VSS
Xi_245 FA_X1 $PINS CO=n_491 S=n_490 A=n_480 B=n_478 CI=n_445 VDD=VDD VSS=VSS
Xi_244 FA_X1 $PINS CO=n_489 S=n_488 A=n_466 B=n_464 CI=n_462 VDD=VDD VSS=VSS
Xi_243 FA_X1 $PINS CO=n_487 S=n_486 A=n_472 B=n_470 CI=n_468 VDD=VDD VSS=VSS
Xi_242 FA_X1 $PINS CO=n_485 S=n_484 A=n_435 B=n_476 CI=n_474 VDD=VDD VSS=VSS
Xi_241 FA_X1 $PINS CO=n_483 S=n_482 A=n_421 B=n_439 CI=n_437 VDD=VDD VSS=VSS
Xi_240 FA_X1 $PINS CO=n_481 S=n_480 A=n_427 B=n_425 CI=n_423 VDD=VDD VSS=VSS
Xi_239 FA_X1 $PINS CO=n_479 S=n_478 A=n_433 B=n_431 CI=n_429 VDD=VDD VSS=VSS
Xi_238 FA_X1 $PINS CO=n_477 S=n_476 A=n_1473 B=n_1495 CI=b_mantissa[0] VDD=VDD
+ VSS=VSS
Xi_237 FA_X1 $PINS CO=n_475 S=n_474 A=n_1407 B=n_1429 CI=n_1451 VDD=VDD VSS=VSS
Xi_236 FA_X1 $PINS CO=n_473 S=n_472 A=n_1341 B=n_1363 CI=n_1385 VDD=VDD VSS=VSS
Xi_235 FA_X1 $PINS CO=n_471 S=n_470 A=n_1275 B=n_1297 CI=n_1319 VDD=VDD VSS=VSS
Xi_234 FA_X1 $PINS CO=n_469 S=n_468 A=n_1209 B=n_1231 CI=n_1253 VDD=VDD VSS=VSS
Xi_233 FA_X1 $PINS CO=n_467 S=n_466 A=n_1143 B=n_1165 CI=n_1187 VDD=VDD VSS=VSS
Xi_232 FA_X1 $PINS CO=n_465 S=n_464 A=n_1077 B=n_1099 CI=n_1121 VDD=VDD VSS=VSS
Xi_231 FA_X1 $PINS CO=n_463 S=n_462 A=a_mantissa[0] B=n_1033 CI=n_1055 VDD=VDD
+ VSS=VSS
Xi_230 HA_X1 $PINS CO=n_461 S=n_460 A=n_417 B=n_458 VDD=VDD VSS=VSS
Xi_229 FA_X1 $PINS CO=n_459 S=n_458 A=n_454 B=n_415 CI=n_456 VDD=VDD VSS=VSS
Xi_228 FA_X1 $PINS CO=n_457 S=n_456 A=n_450 B=n_413 CI=n_452 VDD=VDD VSS=VSS
Xi_227 FA_X1 $PINS CO=n_455 S=n_454 A=n_409 B=n_448 CI=n_411 VDD=VDD VSS=VSS
Xi_226 FA_X1 $PINS CO=n_453 S=n_452 A=n_444 B=n_442 CI=n_446 VDD=VDD VSS=VSS
Xi_225 FA_X1 $PINS CO=n_451 S=n_450 A=n_440 B=n_407 CI=n_405 VDD=VDD VSS=VSS
Xi_224 FA_X1 $PINS CO=n_449 S=n_448 A=n_436 B=n_403 CI=n_401 VDD=VDD VSS=VSS
Xi_223 FA_X1 $PINS CO=n_447 S=n_446 A=n_420 B=n_399 CI=n_438 VDD=VDD VSS=VSS
Xi_222 FA_X1 $PINS CO=n_445 S=n_444 A=n_426 B=n_424 CI=n_422 VDD=VDD VSS=VSS
Xi_221 FA_X1 $PINS CO=n_443 S=n_442 A=n_432 B=n_430 CI=n_428 VDD=VDD VSS=VSS
Xi_220 FA_X1 $PINS CO=n_441 S=n_440 A=n_397 B=n_395 CI=n_434 VDD=VDD VSS=VSS
Xi_219 FA_X1 $PINS CO=n_439 S=n_438 A=n_385 B=n_383 CI=n_381 VDD=VDD VSS=VSS
Xi_218 FA_X1 $PINS CO=n_437 S=n_436 A=n_391 B=n_389 CI=n_387 VDD=VDD VSS=VSS
Xi_217 FA_X1 $PINS CO=n_435 S=n_434 A=n_1496 B=n_1516 CI=n_393 VDD=VDD VSS=VSS
Xi_216 FA_X1 $PINS CO=n_433 S=n_432 A=n_1430 B=n_1452 CI=n_1474 VDD=VDD VSS=VSS
Xi_215 FA_X1 $PINS CO=n_431 S=n_430 A=n_1364 B=n_1386 CI=n_1408 VDD=VDD VSS=VSS
Xi_214 FA_X1 $PINS CO=n_429 S=n_428 A=n_1298 B=n_1320 CI=n_1342 VDD=VDD VSS=VSS
Xi_213 FA_X1 $PINS CO=n_427 S=n_426 A=n_1232 B=n_1254 CI=n_1276 VDD=VDD VSS=VSS
Xi_212 FA_X1 $PINS CO=n_425 S=n_424 A=n_1166 B=n_1188 CI=n_1210 VDD=VDD VSS=VSS
Xi_211 FA_X1 $PINS CO=n_423 S=n_422 A=n_1100 B=n_1122 CI=n_1144 VDD=VDD VSS=VSS
Xi_210 FA_X1 $PINS CO=n_421 S=n_420 A=n_1034 B=n_1056 CI=n_1078 VDD=VDD VSS=VSS
Xi_209 HA_X1 $PINS CO=n_419 S=n_418 A=n_377 B=n_416 VDD=VDD VSS=VSS
Xi_208 FA_X1 $PINS CO=n_417 S=n_416 A=n_375 B=n_412 CI=n_414 VDD=VDD VSS=VSS
Xi_207 FA_X1 $PINS CO=n_415 S=n_414 A=n_371 B=n_373 CI=n_410 VDD=VDD VSS=VSS
Xi_206 FA_X1 $PINS CO=n_413 S=n_412 A=n_369 B=n_408 CI=n_406 VDD=VDD VSS=VSS
Xi_205 FA_X1 $PINS CO=n_411 S=n_410 A=n_404 B=n_402 CI=n_400 VDD=VDD VSS=VSS
Xi_204 FA_X1 $PINS CO=n_409 S=n_408 A=n_363 B=n_361 CI=n_367 VDD=VDD VSS=VSS
Xi_203 FA_X1 $PINS CO=n_407 S=n_406 A=n_396 B=n_394 CI=n_365 VDD=VDD VSS=VSS
Xi_202 FA_X1 $PINS CO=n_405 S=n_404 A=n_382 B=n_380 CI=n_398 VDD=VDD VSS=VSS
Xi_201 FA_X1 $PINS CO=n_403 S=n_402 A=n_388 B=n_386 CI=n_384 VDD=VDD VSS=VSS
Xi_200 FA_X1 $PINS CO=n_401 S=n_400 A=n_357 B=n_392 CI=n_390 VDD=VDD VSS=VSS
Xi_199 FA_X1 $PINS CO=n_399 S=n_398 A=n_345 B=n_343 CI=n_359 VDD=VDD VSS=VSS
Xi_198 FA_X1 $PINS CO=n_397 S=n_396 A=n_351 B=n_349 CI=n_347 VDD=VDD VSS=VSS
Xi_197 FA_X1 $PINS CO=n_395 S=n_394 A=n_1517 B=n_355 CI=n_353 VDD=VDD VSS=VSS
Xi_196 FA_X1 $PINS CO=n_393 S=n_392 A=n_1453 B=n_1475 CI=n_1497 VDD=VDD VSS=VSS
Xi_195 FA_X1 $PINS CO=n_391 S=n_390 A=n_1387 B=n_1409 CI=n_1431 VDD=VDD VSS=VSS
Xi_194 FA_X1 $PINS CO=n_389 S=n_388 A=n_1321 B=n_1343 CI=n_1365 VDD=VDD VSS=VSS
Xi_193 FA_X1 $PINS CO=n_387 S=n_386 A=n_1255 B=n_1277 CI=n_1299 VDD=VDD VSS=VSS
Xi_192 FA_X1 $PINS CO=n_385 S=n_384 A=n_1189 B=n_1211 CI=n_1233 VDD=VDD VSS=VSS
Xi_191 FA_X1 $PINS CO=n_383 S=n_382 A=n_1123 B=n_1145 CI=n_1167 VDD=VDD VSS=VSS
Xi_190 FA_X1 $PINS CO=n_381 S=n_380 A=n_1057 B=n_1079 CI=n_1101 VDD=VDD VSS=VSS
Xi_189 HA_X1 $PINS CO=n_379 S=n_378 A=n_339 B=n_341 VDD=VDD VSS=VSS
Xi_188 FA_X1 $PINS CO=n_377 S=n_376 A=n_337 B=n_372 CI=n_374 VDD=VDD VSS=VSS
Xi_187 FA_X1 $PINS CO=n_375 S=n_374 A=n_333 B=n_335 CI=n_370 VDD=VDD VSS=VSS
Xi_186 FA_X1 $PINS CO=n_373 S=n_372 A=n_362 B=n_368 CI=n_366 VDD=VDD VSS=VSS
Xi_185 FA_X1 $PINS CO=n_371 S=n_370 A=n_331 B=n_329 CI=n_364 VDD=VDD VSS=VSS
Xi_184 FA_X1 $PINS CO=n_369 S=n_368 A=n_327 B=n_325 CI=n_360 VDD=VDD VSS=VSS
Xi_183 FA_X1 $PINS CO=n_367 S=n_366 A=n_323 B=n_358 CI=n_356 VDD=VDD VSS=VSS
Xi_182 FA_X1 $PINS CO=n_365 S=n_364 A=n_346 B=n_344 CI=n_342 VDD=VDD VSS=VSS
Xi_181 FA_X1 $PINS CO=n_363 S=n_362 A=n_352 B=n_350 CI=n_348 VDD=VDD VSS=VSS
Xi_180 FA_X1 $PINS CO=n_361 S=n_360 A=n_321 B=n_319 CI=n_354 VDD=VDD VSS=VSS
Xi_179 FA_X1 $PINS CO=n_359 S=n_358 A=n_311 B=n_309 CI=n_307 VDD=VDD VSS=VSS
Xi_178 FA_X1 $PINS CO=n_357 S=n_356 A=n_317 B=n_315 CI=n_313 VDD=VDD VSS=VSS
Xi_177 FA_X1 $PINS CO=n_355 S=n_354 A=n_1476 B=n_1498 CI=n_1518 VDD=VDD VSS=VSS
Xi_176 FA_X1 $PINS CO=n_353 S=n_352 A=n_1410 B=n_1432 CI=n_1454 VDD=VDD VSS=VSS
Xi_175 FA_X1 $PINS CO=n_351 S=n_350 A=n_1344 B=n_1366 CI=n_1388 VDD=VDD VSS=VSS
Xi_174 FA_X1 $PINS CO=n_349 S=n_348 A=n_1278 B=n_1300 CI=n_1322 VDD=VDD VSS=VSS
Xi_173 FA_X1 $PINS CO=n_347 S=n_346 A=n_1212 B=n_1234 CI=n_1256 VDD=VDD VSS=VSS
Xi_172 FA_X1 $PINS CO=n_345 S=n_344 A=n_1146 B=n_1168 CI=n_1190 VDD=VDD VSS=VSS
Xi_171 FA_X1 $PINS CO=n_343 S=n_342 A=n_1080 B=n_1102 CI=n_1124 VDD=VDD VSS=VSS
Xi_170 HA_X1 $PINS CO=n_341 S=n_340 A=n_303 B=n_338 VDD=VDD VSS=VSS
Xi_169 FA_X1 $PINS CO=n_339 S=n_338 A=n_334 B=n_301 CI=n_336 VDD=VDD VSS=VSS
Xi_168 FA_X1 $PINS CO=n_337 S=n_336 A=n_330 B=n_299 CI=n_332 VDD=VDD VSS=VSS
Xi_167 FA_X1 $PINS CO=n_335 S=n_334 A=n_326 B=n_324 CI=n_297 VDD=VDD VSS=VSS
Xi_166 FA_X1 $PINS CO=n_333 S=n_332 A=n_293 B=n_295 CI=n_328 VDD=VDD VSS=VSS
Xi_165 FA_X1 $PINS CO=n_331 S=n_330 A=n_320 B=n_291 CI=n_289 VDD=VDD VSS=VSS
Xi_164 FA_X1 $PINS CO=n_329 S=n_328 A=n_308 B=n_306 CI=n_322 VDD=VDD VSS=VSS
Xi_163 FA_X1 $PINS CO=n_327 S=n_326 A=n_314 B=n_312 CI=n_310 VDD=VDD VSS=VSS
Xi_162 FA_X1 $PINS CO=n_325 S=n_324 A=n_285 B=n_318 CI=n_316 VDD=VDD VSS=VSS
Xi_161 FA_X1 $PINS CO=n_323 S=n_322 A=n_275 B=n_273 CI=n_287 VDD=VDD VSS=VSS
Xi_160 FA_X1 $PINS CO=n_321 S=n_320 A=n_281 B=n_279 CI=n_277 VDD=VDD VSS=VSS
Xi_159 FA_X1 $PINS CO=n_319 S=n_318 A=n_1499 B=n_1519 CI=n_283 VDD=VDD VSS=VSS
Xi_158 FA_X1 $PINS CO=n_317 S=n_316 A=n_1433 B=n_1455 CI=n_1477 VDD=VDD VSS=VSS
Xi_157 FA_X1 $PINS CO=n_315 S=n_314 A=n_1367 B=n_1389 CI=n_1411 VDD=VDD VSS=VSS
Xi_156 FA_X1 $PINS CO=n_313 S=n_312 A=n_1301 B=n_1323 CI=n_1345 VDD=VDD VSS=VSS
Xi_155 FA_X1 $PINS CO=n_311 S=n_310 A=n_1235 B=n_1257 CI=n_1279 VDD=VDD VSS=VSS
Xi_154 FA_X1 $PINS CO=n_309 S=n_308 A=n_1169 B=n_1191 CI=n_1213 VDD=VDD VSS=VSS
Xi_153 FA_X1 $PINS CO=n_307 S=n_306 A=n_1103 B=n_1125 CI=n_1147 VDD=VDD VSS=VSS
Xi_152 HA_X1 $PINS CO=n_305 S=n_304 A=n_269 B=n_302 VDD=VDD VSS=VSS
Xi_151 FA_X1 $PINS CO=n_303 S=n_302 A=n_267 B=n_298 CI=n_300 VDD=VDD VSS=VSS
Xi_150 FA_X1 $PINS CO=n_301 S=n_300 A=n_294 B=n_265 CI=n_296 VDD=VDD VSS=VSS
Xi_149 FA_X1 $PINS CO=n_299 S=n_298 A=n_261 B=n_292 CI=n_290 VDD=VDD VSS=VSS
Xi_148 FA_X1 $PINS CO=n_297 S=n_296 A=n_257 B=n_288 CI=n_263 VDD=VDD VSS=VSS
Xi_147 FA_X1 $PINS CO=n_295 S=n_294 A=n_286 B=n_284 CI=n_259 VDD=VDD VSS=VSS
Xi_146 FA_X1 $PINS CO=n_293 S=n_292 A=n_274 B=n_272 CI=n_255 VDD=VDD VSS=VSS
Xi_145 FA_X1 $PINS CO=n_291 S=n_290 A=n_280 B=n_278 CI=n_276 VDD=VDD VSS=VSS
Xi_144 FA_X1 $PINS CO=n_289 S=n_288 A=n_241 B=n_253 CI=n_282 VDD=VDD VSS=VSS
Xi_143 FA_X1 $PINS CO=n_287 S=n_286 A=n_247 B=n_245 CI=n_243 VDD=VDD VSS=VSS
Xi_142 FA_X1 $PINS CO=n_285 S=n_284 A=n_1520 B=n_251 CI=n_249 VDD=VDD VSS=VSS
Xi_141 FA_X1 $PINS CO=n_283 S=n_282 A=n_1456 B=n_1478 CI=n_1500 VDD=VDD VSS=VSS
Xi_140 FA_X1 $PINS CO=n_281 S=n_280 A=n_1390 B=n_1412 CI=n_1434 VDD=VDD VSS=VSS
Xi_139 FA_X1 $PINS CO=n_279 S=n_278 A=n_1324 B=n_1346 CI=n_1368 VDD=VDD VSS=VSS
Xi_138 FA_X1 $PINS CO=n_277 S=n_276 A=n_1258 B=n_1280 CI=n_1302 VDD=VDD VSS=VSS
Xi_137 FA_X1 $PINS CO=n_275 S=n_274 A=n_1192 B=n_1214 CI=n_1236 VDD=VDD VSS=VSS
Xi_136 FA_X1 $PINS CO=n_273 S=n_272 A=n_1126 B=n_1148 CI=n_1170 VDD=VDD VSS=VSS
Xi_135 HA_X1 $PINS CO=n_271 S=n_270 A=n_237 B=n_239 VDD=VDD VSS=VSS
Xi_134 FA_X1 $PINS CO=n_269 S=n_268 A=n_235 B=n_264 CI=n_266 VDD=VDD VSS=VSS
Xi_133 FA_X1 $PINS CO=n_267 S=n_266 A=n_260 B=n_262 CI=n_233 VDD=VDD VSS=VSS
Xi_132 FA_X1 $PINS CO=n_265 S=n_264 A=n_231 B=n_258 CI=n_256 VDD=VDD VSS=VSS
Xi_131 FA_X1 $PINS CO=n_263 S=n_262 A=n_252 B=n_229 CI=n_227 VDD=VDD VSS=VSS
Xi_130 FA_X1 $PINS CO=n_261 S=n_260 A=n_240 B=n_225 CI=n_254 VDD=VDD VSS=VSS
Xi_129 FA_X1 $PINS CO=n_259 S=n_258 A=n_246 B=n_244 CI=n_242 VDD=VDD VSS=VSS
Xi_128 FA_X1 $PINS CO=n_257 S=n_256 A=n_221 B=n_250 CI=n_248 VDD=VDD VSS=VSS
Xi_127 FA_X1 $PINS CO=n_255 S=n_254 A=n_213 B=n_211 CI=n_223 VDD=VDD VSS=VSS
Xi_126 FA_X1 $PINS CO=n_253 S=n_252 A=n_219 B=n_217 CI=n_215 VDD=VDD VSS=VSS
Xi_125 FA_X1 $PINS CO=n_251 S=n_250 A=n_1479 B=n_1501 CI=n_1521 VDD=VDD VSS=VSS
Xi_124 FA_X1 $PINS CO=n_249 S=n_248 A=n_1413 B=n_1435 CI=n_1457 VDD=VDD VSS=VSS
Xi_123 FA_X1 $PINS CO=n_247 S=n_246 A=n_1347 B=n_1369 CI=n_1391 VDD=VDD VSS=VSS
Xi_122 FA_X1 $PINS CO=n_245 S=n_244 A=n_1281 B=n_1303 CI=n_1325 VDD=VDD VSS=VSS
Xi_121 FA_X1 $PINS CO=n_243 S=n_242 A=n_1215 B=n_1237 CI=n_1259 VDD=VDD VSS=VSS
Xi_120 FA_X1 $PINS CO=n_241 S=n_240 A=n_1149 B=n_1171 CI=n_1193 VDD=VDD VSS=VSS
Xi_119 HA_X1 $PINS CO=n_239 S=n_238 A=n_207 B=n_209 VDD=VDD VSS=VSS
Xi_118 FA_X1 $PINS CO=n_237 S=n_236 A=n_232 B=n_205 CI=n_234 VDD=VDD VSS=VSS
Xi_117 FA_X1 $PINS CO=n_235 S=n_234 A=n_226 B=n_230 CI=n_203 VDD=VDD VSS=VSS
Xi_116 FA_X1 $PINS CO=n_233 S=n_232 A=n_224 B=n_201 CI=n_228 VDD=VDD VSS=VSS
Xi_115 FA_X1 $PINS CO=n_231 S=n_230 A=n_222 B=n_199 CI=n_197 VDD=VDD VSS=VSS
Xi_114 FA_X1 $PINS CO=n_229 S=n_228 A=n_214 B=n_212 CI=n_210 VDD=VDD VSS=VSS
Xi_113 FA_X1 $PINS CO=n_227 S=n_226 A=n_220 B=n_218 CI=n_216 VDD=VDD VSS=VSS
Xi_112 FA_X1 $PINS CO=n_225 S=n_224 A=n_183 B=n_195 CI=n_193 VDD=VDD VSS=VSS
Xi_111 FA_X1 $PINS CO=n_223 S=n_222 A=n_189 B=n_187 CI=n_185 VDD=VDD VSS=VSS
Xi_110 FA_X1 $PINS CO=n_221 S=n_220 A=n_1502 B=n_1522 CI=n_191 VDD=VDD VSS=VSS
Xi_109 FA_X1 $PINS CO=n_219 S=n_218 A=n_1436 B=n_1458 CI=n_1480 VDD=VDD VSS=VSS
Xi_108 FA_X1 $PINS CO=n_217 S=n_216 A=n_1370 B=n_1392 CI=n_1414 VDD=VDD VSS=VSS
Xi_107 FA_X1 $PINS CO=n_215 S=n_214 A=n_1304 B=n_1326 CI=n_1348 VDD=VDD VSS=VSS
Xi_106 FA_X1 $PINS CO=n_213 S=n_212 A=n_1238 B=n_1260 CI=n_1282 VDD=VDD VSS=VSS
Xi_105 FA_X1 $PINS CO=n_211 S=n_210 A=n_1172 B=n_1194 CI=n_1216 VDD=VDD VSS=VSS
Xi_104 HA_X1 $PINS CO=n_209 S=n_208 A=n_179 B=n_181 VDD=VDD VSS=VSS
Xi_103 FA_X1 $PINS CO=n_207 S=n_206 A=n_177 B=n_202 CI=n_204 VDD=VDD VSS=VSS
Xi_102 FA_X1 $PINS CO=n_205 S=n_204 A=n_196 B=n_175 CI=n_200 VDD=VDD VSS=VSS
Xi_101 FA_X1 $PINS CO=n_203 S=n_202 A=n_171 B=n_173 CI=n_198 VDD=VDD VSS=VSS
Xi_100 FA_X1 $PINS CO=n_201 S=n_200 A=n_169 B=n_194 CI=n_192 VDD=VDD VSS=VSS
Xi_99 FA_X1 $PINS CO=n_199 S=n_198 A=n_186 B=n_184 CI=n_182 VDD=VDD VSS=VSS
Xi_98 FA_X1 $PINS CO=n_197 S=n_196 A=n_167 B=n_190 CI=n_188 VDD=VDD VSS=VSS
Xi_97 FA_X1 $PINS CO=n_195 S=n_194 A=n_161 B=n_159 CI=n_157 VDD=VDD VSS=VSS
Xi_96 FA_X1 $PINS CO=n_193 S=n_192 A=n_1523 B=n_165 CI=n_163 VDD=VDD VSS=VSS
Xi_95 FA_X1 $PINS CO=n_191 S=n_190 A=n_1459 B=n_1481 CI=n_1503 VDD=VDD VSS=VSS
Xi_94 FA_X1 $PINS CO=n_189 S=n_188 A=n_1393 B=n_1415 CI=n_1437 VDD=VDD VSS=VSS
Xi_93 FA_X1 $PINS CO=n_187 S=n_186 A=n_1327 B=n_1349 CI=n_1371 VDD=VDD VSS=VSS
Xi_92 FA_X1 $PINS CO=n_185 S=n_184 A=n_1261 B=n_1283 CI=n_1305 VDD=VDD VSS=VSS
Xi_91 FA_X1 $PINS CO=n_183 S=n_182 A=n_1195 B=n_1217 CI=n_1239 VDD=VDD VSS=VSS
Xi_90 HA_X1 $PINS CO=n_181 S=n_180 A=n_153 B=n_155 VDD=VDD VSS=VSS
Xi_89 FA_X1 $PINS CO=n_179 S=n_178 A=n_174 B=n_151 CI=n_176 VDD=VDD VSS=VSS
Xi_88 FA_X1 $PINS CO=n_177 S=n_176 A=n_149 B=n_172 CI=n_170 VDD=VDD VSS=VSS
Xi_87 FA_X1 $PINS CO=n_175 S=n_174 A=n_147 B=n_145 CI=n_168 VDD=VDD VSS=VSS
Xi_86 FA_X1 $PINS CO=n_173 S=n_172 A=n_158 B=n_156 CI=n_166 VDD=VDD VSS=VSS
Xi_85 FA_X1 $PINS CO=n_171 S=n_170 A=n_164 B=n_162 CI=n_160 VDD=VDD VSS=VSS
Xi_84 FA_X1 $PINS CO=n_169 S=n_168 A=n_133 B=n_143 CI=n_141 VDD=VDD VSS=VSS
Xi_83 FA_X1 $PINS CO=n_167 S=n_166 A=n_139 B=n_137 CI=n_135 VDD=VDD VSS=VSS
Xi_82 FA_X1 $PINS CO=n_165 S=n_164 A=n_1482 B=n_1504 CI=n_1524 VDD=VDD VSS=VSS
Xi_81 FA_X1 $PINS CO=n_163 S=n_162 A=n_1416 B=n_1438 CI=n_1460 VDD=VDD VSS=VSS
Xi_80 FA_X1 $PINS CO=n_161 S=n_160 A=n_1350 B=n_1372 CI=n_1394 VDD=VDD VSS=VSS
Xi_79 FA_X1 $PINS CO=n_159 S=n_158 A=n_1284 B=n_1306 CI=n_1328 VDD=VDD VSS=VSS
Xi_78 FA_X1 $PINS CO=n_157 S=n_156 A=n_1218 B=n_1240 CI=n_1262 VDD=VDD VSS=VSS
Xi_77 HA_X1 $PINS CO=n_155 S=n_154 A=n_150 B=n_131 VDD=VDD VSS=VSS
Xi_76 FA_X1 $PINS CO=n_153 S=n_152 A=n_148 B=n_127 CI=n_129 VDD=VDD VSS=VSS
Xi_75 FA_X1 $PINS CO=n_151 S=n_150 A=n_125 B=n_146 CI=n_144 VDD=VDD VSS=VSS
Xi_74 FA_X1 $PINS CO=n_149 S=n_148 A=n_121 B=n_142 CI=n_123 VDD=VDD VSS=VSS
Xi_73 FA_X1 $PINS CO=n_147 S=n_146 A=n_136 B=n_134 CI=n_132 VDD=VDD VSS=VSS
Xi_72 FA_X1 $PINS CO=n_145 S=n_144 A=n_119 B=n_140 CI=n_138 VDD=VDD VSS=VSS
Xi_71 FA_X1 $PINS CO=n_143 S=n_142 A=n_115 B=n_113 CI=n_111 VDD=VDD VSS=VSS
Xi_70 FA_X1 $PINS CO=n_141 S=n_140 A=n_1505 B=n_1525 CI=n_117 VDD=VDD VSS=VSS
Xi_69 FA_X1 $PINS CO=n_139 S=n_138 A=n_1439 B=n_1461 CI=n_1483 VDD=VDD VSS=VSS
Xi_68 FA_X1 $PINS CO=n_137 S=n_136 A=n_1373 B=n_1395 CI=n_1417 VDD=VDD VSS=VSS
Xi_67 FA_X1 $PINS CO=n_135 S=n_134 A=n_1307 B=n_1329 CI=n_1351 VDD=VDD VSS=VSS
Xi_66 FA_X1 $PINS CO=n_133 S=n_132 A=n_1241 B=n_1263 CI=n_1285 VDD=VDD VSS=VSS
Xi_65 HA_X1 $PINS CO=n_131 S=n_130 A=n_107 B=n_109 VDD=VDD VSS=VSS
Xi_64 FA_X1 $PINS CO=n_129 S=n_128 A=n_105 B=n_124 CI=n_126 VDD=VDD VSS=VSS
Xi_63 FA_X1 $PINS CO=n_127 S=n_126 A=n_101 B=n_103 CI=n_122 VDD=VDD VSS=VSS
Xi_62 FA_X1 $PINS CO=n_125 S=n_124 A=n_110 B=n_120 CI=n_118 VDD=VDD VSS=VSS
Xi_61 FA_X1 $PINS CO=n_123 S=n_122 A=n_116 B=n_114 CI=n_112 VDD=VDD VSS=VSS
Xi_60 FA_X1 $PINS CO=n_121 S=n_120 A=n_93 B=n_91 CI=n_99 VDD=VDD VSS=VSS
Xi_59 FA_X1 $PINS CO=n_119 S=n_118 A=n_1526 B=n_97 CI=n_95 VDD=VDD VSS=VSS
Xi_58 FA_X1 $PINS CO=n_117 S=n_116 A=n_1462 B=n_1484 CI=n_1506 VDD=VDD VSS=VSS
Xi_57 FA_X1 $PINS CO=n_115 S=n_114 A=n_1396 B=n_1418 CI=n_1440 VDD=VDD VSS=VSS
Xi_56 FA_X1 $PINS CO=n_113 S=n_112 A=n_1330 B=n_1352 CI=n_1374 VDD=VDD VSS=VSS
Xi_55 FA_X1 $PINS CO=n_111 S=n_110 A=n_1264 B=n_1286 CI=n_1308 VDD=VDD VSS=VSS
Xi_54 HA_X1 $PINS CO=n_109 S=n_108 A=n_89 B=n_87 VDD=VDD VSS=VSS
Xi_53 FA_X1 $PINS CO=n_107 S=n_106 A=n_102 B=n_100 CI=n_104 VDD=VDD VSS=VSS
Xi_52 FA_X1 $PINS CO=n_105 S=n_104 A=n_98 B=n_83 CI=n_85 VDD=VDD VSS=VSS
Xi_51 FA_X1 $PINS CO=n_103 S=n_102 A=n_92 B=n_90 CI=n_81 VDD=VDD VSS=VSS
Xi_50 FA_X1 $PINS CO=n_101 S=n_100 A=n_79 B=n_96 CI=n_94 VDD=VDD VSS=VSS
Xi_49 FA_X1 $PINS CO=n_99 S=n_98 A=n_77 B=n_75 CI=n_73 VDD=VDD VSS=VSS
Xi_48 FA_X1 $PINS CO=n_97 S=n_96 A=n_1485 B=n_1507 CI=n_1527 VDD=VDD VSS=VSS
Xi_47 FA_X1 $PINS CO=n_95 S=n_94 A=n_1419 B=n_1441 CI=n_1463 VDD=VDD VSS=VSS
Xi_46 FA_X1 $PINS CO=n_93 S=n_92 A=n_1353 B=n_1375 CI=n_1397 VDD=VDD VSS=VSS
Xi_45 FA_X1 $PINS CO=n_91 S=n_90 A=n_1287 B=n_1309 CI=n_1331 VDD=VDD VSS=VSS
Xi_44 HA_X1 $PINS CO=n_89 S=n_88 A=n_71 B=n_69 VDD=VDD VSS=VSS
Xi_43 FA_X1 $PINS CO=n_87 S=n_86 A=n_67 B=n_82 CI=n_84 VDD=VDD VSS=VSS
Xi_42 FA_X1 $PINS CO=n_85 S=n_84 A=n_72 B=n_80 CI=n_65 VDD=VDD VSS=VSS
Xi_41 FA_X1 $PINS CO=n_83 S=n_82 A=n_78 B=n_76 CI=n_74 VDD=VDD VSS=VSS
Xi_40 FA_X1 $PINS CO=n_81 S=n_80 A=n_59 B=n_57 CI=n_63 VDD=VDD VSS=VSS
Xi_39 FA_X1 $PINS CO=n_79 S=n_78 A=n_1508 B=n_1528 CI=n_61 VDD=VDD VSS=VSS
Xi_38 FA_X1 $PINS CO=n_77 S=n_76 A=n_1442 B=n_1464 CI=n_1486 VDD=VDD VSS=VSS
Xi_37 FA_X1 $PINS CO=n_75 S=n_74 A=n_1376 B=n_1398 CI=n_1420 VDD=VDD VSS=VSS
Xi_36 FA_X1 $PINS CO=n_73 S=n_72 A=n_1310 B=n_1332 CI=n_1354 VDD=VDD VSS=VSS
Xi_35 HA_X1 $PINS CO=n_71 S=n_70 A=n_55 B=n_53 VDD=VDD VSS=VSS
Xi_34 FA_X1 $PINS CO=n_69 S=n_68 A=n_51 B=n_64 CI=n_66 VDD=VDD VSS=VSS
Xi_33 FA_X1 $PINS CO=n_67 S=n_66 A=n_56 B=n_49 CI=n_62 VDD=VDD VSS=VSS
Xi_32 FA_X1 $PINS CO=n_65 S=n_64 A=n_43 B=n_60 CI=n_58 VDD=VDD VSS=VSS
Xi_31 FA_X1 $PINS CO=n_63 S=n_62 A=n_1529 B=n_47 CI=n_45 VDD=VDD VSS=VSS
Xi_30 FA_X1 $PINS CO=n_61 S=n_60 A=n_1465 B=n_1487 CI=n_1509 VDD=VDD VSS=VSS
Xi_29 FA_X1 $PINS CO=n_59 S=n_58 A=n_1399 B=n_1421 CI=n_1443 VDD=VDD VSS=VSS
Xi_28 FA_X1 $PINS CO=n_57 S=n_56 A=n_1333 B=n_1355 CI=n_1377 VDD=VDD VSS=VSS
Xi_27 HA_X1 $PINS CO=n_55 S=n_54 A=n_39 B=n_50 VDD=VDD VSS=VSS
Xi_26 FA_X1 $PINS CO=n_53 S=n_52 A=n_48 B=n_37 CI=n_41 VDD=VDD VSS=VSS
Xi_25 FA_X1 $PINS CO=n_51 S=n_50 A=n_46 B=n_44 CI=n_42 VDD=VDD VSS=VSS
Xi_24 FA_X1 $PINS CO=n_49 S=n_48 A=n_33 B=n_31 CI=n_35 VDD=VDD VSS=VSS
Xi_23 FA_X1 $PINS CO=n_47 S=n_46 A=n_1488 B=n_1510 CI=n_1530 VDD=VDD VSS=VSS
Xi_22 FA_X1 $PINS CO=n_45 S=n_44 A=n_1422 B=n_1444 CI=n_1466 VDD=VDD VSS=VSS
Xi_21 FA_X1 $PINS CO=n_43 S=n_42 A=n_1356 B=n_1378 CI=n_1400 VDD=VDD VSS=VSS
Xi_20 HA_X1 $PINS CO=n_41 S=n_40 A=n_36 B=n_27 VDD=VDD VSS=VSS
Xi_19 FA_X1 $PINS CO=n_39 S=n_38 A=n_32 B=n_30 CI=n_29 VDD=VDD VSS=VSS
Xi_18 FA_X1 $PINS CO=n_37 S=n_36 A=n_21 B=n_25 CI=n_34 VDD=VDD VSS=VSS
Xi_17 FA_X1 $PINS CO=n_35 S=n_34 A=n_1511 B=n_1531 CI=n_23 VDD=VDD VSS=VSS
Xi_16 FA_X1 $PINS CO=n_33 S=n_32 A=n_1445 B=n_1467 CI=n_1489 VDD=VDD VSS=VSS
Xi_15 FA_X1 $PINS CO=n_31 S=n_30 A=n_1379 B=n_1401 CI=n_1423 VDD=VDD VSS=VSS
Xi_14 HA_X1 $PINS CO=n_29 S=n_28 A=n_19 B=n_17 VDD=VDD VSS=VSS
Xi_13 FA_X1 $PINS CO=n_27 S=n_26 A=n_22 B=n_20 CI=n_24 VDD=VDD VSS=VSS
Xi_12 FA_X1 $PINS CO=n_25 S=n_24 A=n_1532 B=n_15 CI=n_13 VDD=VDD VSS=VSS
Xi_11 FA_X1 $PINS CO=n_23 S=n_22 A=n_1468 B=n_1490 CI=n_1512 VDD=VDD VSS=VSS
Xi_10 FA_X1 $PINS CO=n_21 S=n_20 A=n_1402 B=n_1424 CI=n_1446 VDD=VDD VSS=VSS
Xi_9 HA_X1 $PINS CO=n_19 S=n_18 A=n_12 B=n_11 VDD=VDD VSS=VSS
Xi_8 FA_X1 $PINS CO=n_17 S=n_16 A=n_7 B=n_9 CI=n_14 VDD=VDD VSS=VSS
Xi_7 FA_X1 $PINS CO=n_15 S=n_14 A=n_1491 B=n_1513 CI=n_1533 VDD=VDD VSS=VSS
Xi_6 FA_X1 $PINS CO=n_13 S=n_12 A=n_1425 B=n_1447 CI=n_1469 VDD=VDD VSS=VSS
Xi_5 HA_X1 $PINS CO=n_11 S=n_10 A=n_3 B=n_8 VDD=VDD VSS=VSS
Xi_4 FA_X1 $PINS CO=n_9 S=n_8 A=n_1514 B=n_1534 CI=n_5 VDD=VDD VSS=VSS
Xi_3 FA_X1 $PINS CO=n_7 S=n_6 A=n_1448 B=n_1470 CI=n_1492 VDD=VDD VSS=VSS
Xi_2 HA_X1 $PINS CO=n_5 S=n_4 A=n_1535 B=n_1 VDD=VDD VSS=VSS
Xi_1 FA_X1 $PINS CO=n_3 S=n_2 A=n_1471 B=n_1493 CI=n_1515 VDD=VDD VSS=VSS
Xi_0 HA_X1 $PINS CO=n_1 S=n_0 A=n_1494 B=n_1785 VDD=VDD VSS=VSS
.ENDS

.SUBCKT FloatingPointMultiplier VDD VSS A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31]
+ B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18]
+ B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4]
+ B[3] B[2] B[1] B[0] O[31] O[30] O[29] O[28] O[27] O[26] O[25] O[24] O[23]
+ O[22] O[21] O[20] O[19] O[18] O[17] O[16] O[15] O[14] O[13] O[12] O[11] O[10]
+ O[9] O[8] O[7] O[6] O[5] O[4] O[3] O[2] O[1] O[0] OF
Xi_1_148 INV_X1 $PINS ZN=n_1_105 A=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_125 NOR4_X1 $PINS ZN=n_1_73 A1=o_mantissa[21] A2=o_mantissa[20]
+ A3=o_mantissa[18] A4=o_mantissa[15] VDD=VDD VSS=VSS
Xi_1_124 NOR4_X1 $PINS ZN=n_1_72 A1=o_mantissa[22] A2=o_mantissa[19]
+ A3=o_mantissa[17] A4=o_mantissa[16] VDD=VDD VSS=VSS
Xi_1_93 NAND2_X1 $PINS ZN=n_1_71 A1=n_1_73 A2=n_1_72 VDD=VDD VSS=VSS
Xi_1_92 NOR4_X1 $PINS ZN=n_1_70 A1=o_mantissa[10] A2=o_mantissa[9]
+ A3=o_mantissa[8] A4=o_mantissa[7] VDD=VDD VSS=VSS
Xi_1_91 NOR4_X1 $PINS ZN=n_1_69 A1=o_mantissa[14] A2=o_mantissa[13]
+ A3=o_mantissa[12] A4=o_mantissa[11] VDD=VDD VSS=VSS
Xi_1_90 NOR3_X1 $PINS ZN=n_1_68 A1=o_mantissa[2] A2=o_mantissa[1]
+ A3=o_mantissa[0] VDD=VDD VSS=VSS
Xi_1_89 NOR4_X1 $PINS ZN=n_1_67 A1=o_mantissa[6] A2=o_mantissa[5]
+ A3=o_mantissa[4] A4=o_mantissa[3] VDD=VDD VSS=VSS
Xi_1_88 NAND4_X1 $PINS ZN=n_1_66 A1=n_1_70 A2=n_1_69 A3=n_1_68 A4=n_1_67
+ VDD=VDD VSS=VSS
Xi_1_87 OAI222_X1 $PINS ZN=n_1_65 A1=n_1_105 A2=o_mantissa[23]
+ B1=o_mantissa[47] B2=o_mantissa[22] C1=n_1_71 C2=n_1_66 VDD=VDD VSS=VSS
Xi_1_86 INV_X1 $PINS ZN=n_46 A=n_1_65 VDD=VDD VSS=VSS
Xi_1_147 INV_X1 $PINS ZN=n_1_104 A=n_22 VDD=VDD VSS=VSS
Xi_1_146 INV_X1 $PINS ZN=n_1_103 A=n_21 VDD=VDD VSS=VSS
Xi_1_145 INV_X1 $PINS ZN=n_1_102 A=n_20 VDD=VDD VSS=VSS
Xi_1_144 INV_X1 $PINS ZN=n_1_101 A=n_19 VDD=VDD VSS=VSS
Xi_1_143 INV_X1 $PINS ZN=n_1_100 A=n_18 VDD=VDD VSS=VSS
Xi_1_142 INV_X1 $PINS ZN=n_1_99 A=n_17 VDD=VDD VSS=VSS
Xi_1_141 INV_X1 $PINS ZN=n_1_98 A=n_16 VDD=VDD VSS=VSS
Xi_1_140 INV_X1 $PINS ZN=n_1_97 A=n_15 VDD=VDD VSS=VSS
Xi_1_139 INV_X1 $PINS ZN=n_1_96 A=n_14 VDD=VDD VSS=VSS
Xi_1_138 INV_X1 $PINS ZN=n_1_95 A=n_13 VDD=VDD VSS=VSS
Xi_1_137 INV_X1 $PINS ZN=n_1_94 A=n_12 VDD=VDD VSS=VSS
Xi_1_136 INV_X1 $PINS ZN=n_1_93 A=n_11 VDD=VDD VSS=VSS
Xi_1_135 INV_X1 $PINS ZN=n_1_92 A=n_10 VDD=VDD VSS=VSS
Xi_1_134 INV_X1 $PINS ZN=n_1_91 A=n_9 VDD=VDD VSS=VSS
Xi_1_133 INV_X1 $PINS ZN=n_1_90 A=n_8 VDD=VDD VSS=VSS
Xi_1_132 INV_X1 $PINS ZN=n_1_89 A=n_7 VDD=VDD VSS=VSS
Xi_1_131 INV_X1 $PINS ZN=n_1_88 A=n_6 VDD=VDD VSS=VSS
Xi_1_130 INV_X1 $PINS ZN=n_1_87 A=n_5 VDD=VDD VSS=VSS
Xi_1_129 INV_X1 $PINS ZN=n_1_86 A=n_4 VDD=VDD VSS=VSS
Xi_1_128 INV_X1 $PINS ZN=n_1_85 A=n_3 VDD=VDD VSS=VSS
Xi_1_127 INV_X1 $PINS ZN=n_1_84 A=n_2 VDD=VDD VSS=VSS
Xi_1_126 INV_X1 $PINS ZN=n_1_83 A=n_1 VDD=VDD VSS=VSS
Xi_1_85 INV_X1 $PINS ZN=n_1_82 A=n_0 VDD=VDD VSS=VSS
Xi_1_84 INV_X1 $PINS ZN=n_1_81 A=n_1_15 VDD=VDD VSS=VSS
Xi_1_123 INV_X1 $PINS ZN=n_1_80 A=n_1_24 VDD=VDD VSS=VSS
Xi_1_122 INV_X1 $PINS ZN=n_1_79 A=n_1_25 VDD=VDD VSS=VSS
Xi_1_121 INV_X1 $PINS ZN=n_1_78 A=n_1_26 VDD=VDD VSS=VSS
Xi_1_120 INV_X1 $PINS ZN=n_1_77 A=n_1_27 VDD=VDD VSS=VSS
Xi_1_119 INV_X1 $PINS ZN=n_1_76 A=n_1_28 VDD=VDD VSS=VSS
Xi_1_118 INV_X1 $PINS ZN=n_1_75 A=n_1_29 VDD=VDD VSS=VSS
Xi_1_117 INV_X1 $PINS ZN=n_1_74 A=n_1_30 VDD=VDD VSS=VSS
Xi_1_116 MUX2_X1 $PINS Z=n_45 A=o_mantissa[45] B=o_mantissa[46]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_115 MUX2_X1 $PINS Z=n_44 A=o_mantissa[44] B=o_mantissa[45]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_114 MUX2_X1 $PINS Z=n_43 A=o_mantissa[43] B=o_mantissa[44]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_113 MUX2_X1 $PINS Z=n_42 A=o_mantissa[42] B=o_mantissa[43]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_112 MUX2_X1 $PINS Z=n_41 A=o_mantissa[41] B=o_mantissa[42]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_111 MUX2_X1 $PINS Z=n_40 A=o_mantissa[40] B=o_mantissa[41]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_110 MUX2_X1 $PINS Z=n_39 A=o_mantissa[39] B=o_mantissa[40]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_109 MUX2_X1 $PINS Z=n_38 A=o_mantissa[38] B=o_mantissa[39]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_108 MUX2_X1 $PINS Z=n_37 A=o_mantissa[37] B=o_mantissa[38]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_107 MUX2_X1 $PINS Z=n_36 A=o_mantissa[36] B=o_mantissa[37]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_106 MUX2_X1 $PINS Z=n_35 A=o_mantissa[35] B=o_mantissa[36]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_105 MUX2_X1 $PINS Z=n_34 A=o_mantissa[34] B=o_mantissa[35]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_104 MUX2_X1 $PINS Z=n_33 A=o_mantissa[33] B=o_mantissa[34]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_103 MUX2_X1 $PINS Z=n_32 A=o_mantissa[32] B=o_mantissa[33]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_102 MUX2_X1 $PINS Z=n_31 A=o_mantissa[31] B=o_mantissa[32]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_101 MUX2_X1 $PINS Z=n_30 A=o_mantissa[30] B=o_mantissa[31]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_100 MUX2_X1 $PINS Z=n_29 A=o_mantissa[29] B=o_mantissa[30]
+ S=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_99 MUX2_X1 $PINS Z=n_28 A=o_mantissa[28] B=o_mantissa[29] S=o_mantissa[47]
+ VDD=VDD VSS=VSS
Xi_1_98 MUX2_X1 $PINS Z=n_27 A=o_mantissa[27] B=o_mantissa[28] S=o_mantissa[47]
+ VDD=VDD VSS=VSS
Xi_1_97 MUX2_X1 $PINS Z=n_26 A=o_mantissa[26] B=o_mantissa[27] S=o_mantissa[47]
+ VDD=VDD VSS=VSS
Xi_1_96 MUX2_X1 $PINS Z=n_25 A=o_mantissa[25] B=o_mantissa[26] S=o_mantissa[47]
+ VDD=VDD VSS=VSS
Xi_1_95 MUX2_X1 $PINS Z=n_24 A=o_mantissa[24] B=o_mantissa[25] S=o_mantissa[47]
+ VDD=VDD VSS=VSS
Xi_1_94 MUX2_X1 $PINS Z=n_23 A=o_mantissa[23] B=o_mantissa[24] S=o_mantissa[47]
+ VDD=VDD VSS=VSS
Xi_1_83 XOR2_X1 $PINS Z=O[31] A=B[31] B=A[31] VDD=VDD VSS=VSS
Xi_1_82 NAND4_X1 $PINS ZN=n_1_64 A1=A[26] A2=A[25] A3=A[24] A4=A[23] VDD=VDD
+ VSS=VSS
Xi_1_81 NAND4_X1 $PINS ZN=n_1_63 A1=A[30] A2=A[29] A3=A[28] A4=A[27] VDD=VDD
+ VSS=VSS
Xi_1_80 NOR2_X1 $PINS ZN=n_1_62 A1=n_1_64 A2=n_1_63 VDD=VDD VSS=VSS
Xi_1_79 NAND4_X1 $PINS ZN=n_1_61 A1=B[26] A2=B[25] A3=B[24] A4=B[23] VDD=VDD
+ VSS=VSS
Xi_1_78 NAND4_X1 $PINS ZN=n_1_60 A1=B[30] A2=B[29] A3=B[28] A4=B[27] VDD=VDD
+ VSS=VSS
Xi_1_77 NOR2_X1 $PINS ZN=n_1_59 A1=n_1_61 A2=n_1_60 VDD=VDD VSS=VSS
Xi_1_76 NOR2_X1 $PINS ZN=n_1_58 A1=n_1_62 A2=n_1_59 VDD=VDD VSS=VSS
Xi_1_75 NOR4_X1 $PINS ZN=n_1_57 A1=A[21] A2=A[20] A3=A[18] A4=A[15] VDD=VDD
+ VSS=VSS
Xi_1_74 NOR4_X1 $PINS ZN=n_1_56 A1=A[22] A2=A[19] A3=A[17] A4=A[16] VDD=VDD
+ VSS=VSS
Xi_1_73 NOR4_X1 $PINS ZN=n_1_55 A1=A[14] A2=A[11] A3=A[9] A4=A[8] VDD=VDD
+ VSS=VSS
Xi_1_72 NOR3_X1 $PINS ZN=n_1_54 A1=A[5] A2=A[4] A3=A[1] VDD=VDD VSS=VSS
Xi_1_71 NOR4_X1 $PINS ZN=n_1_53 A1=A[13] A2=A[12] A3=A[10] A4=A[7] VDD=VDD
+ VSS=VSS
Xi_1_70 NOR4_X2 $PINS ZN=n_1_52 A1=A[6] A2=A[3] A3=A[2] A4=A[0] VDD=VDD VSS=VSS
Xi_1_69 AND4_X1 $PINS ZN=n_1_51 A1=n_1_57 A2=n_1_56 A3=n_1_53 A4=n_1_52 VDD=VDD
+ VSS=VSS
Xi_1_68 NAND3_X1 $PINS ZN=n_1_50 A1=n_1_55 A2=n_1_54 A3=n_1_51 VDD=VDD VSS=VSS
Xi_1_67 OR4_X1 $PINS ZN=n_1_49 A1=A[26] A2=A[25] A3=A[24] A4=A[23] VDD=VDD
+ VSS=VSS
Xi_1_66 OR4_X1 $PINS ZN=n_1_48 A1=A[30] A2=A[29] A3=A[28] A4=A[27] VDD=VDD
+ VSS=VSS
Xi_1_65 NOR4_X1 $PINS ZN=n_1_47 A1=B[21] A2=B[20] A3=B[18] A4=B[15] VDD=VDD
+ VSS=VSS
Xi_1_64 NOR4_X1 $PINS ZN=n_1_46 A1=B[22] A2=B[19] A3=B[17] A4=B[16] VDD=VDD
+ VSS=VSS
Xi_1_63 NOR4_X1 $PINS ZN=n_1_45 A1=B[14] A2=B[11] A3=B[9] A4=B[8] VDD=VDD
+ VSS=VSS
Xi_1_62 NOR3_X1 $PINS ZN=n_1_44 A1=B[5] A2=B[4] A3=B[1] VDD=VDD VSS=VSS
Xi_1_61 NOR4_X1 $PINS ZN=n_1_43 A1=B[13] A2=B[12] A3=B[10] A4=B[7] VDD=VDD
+ VSS=VSS
Xi_1_60 NOR4_X1 $PINS ZN=n_1_42 A1=B[6] A2=B[3] A3=B[2] A4=B[0] VDD=VDD VSS=VSS
Xi_1_59 AND4_X1 $PINS ZN=n_1_41 A1=n_1_47 A2=n_1_46 A3=n_1_43 A4=n_1_42 VDD=VDD
+ VSS=VSS
Xi_1_58 NAND3_X1 $PINS ZN=n_1_40 A1=n_1_45 A2=n_1_44 A3=n_1_41 VDD=VDD VSS=VSS
Xi_1_57 OR4_X1 $PINS ZN=n_1_39 A1=B[30] A2=B[25] A3=B[24] A4=B[23] VDD=VDD
+ VSS=VSS
Xi_1_56 OR4_X1 $PINS ZN=n_1_38 A1=B[29] A2=B[28] A3=B[27] A4=B[26] VDD=VDD
+ VSS=VSS
Xi_1_55 OAI33_X1 $PINS ZN=n_1_37 A1=n_1_50 A2=n_1_49 A3=n_1_48 B1=n_1_40
+ B2=n_1_39 B3=n_1_38 VDD=VDD VSS=VSS
Xi_1_54 INV_X1 $PINS ZN=n_1_36 A=drc_ipo_n6 VDD=VDD VSS=VSS
Xi_1_53 OAI21_X1 $PINS ZN=O[30] A=n_1_58 B1=drc_ipo_n6 B2=n_1_74 VDD=VDD
+ VSS=VSS
Xi_1_52 OAI21_X1 $PINS ZN=O[29] A=n_1_58 B1=drc_ipo_n6 B2=n_1_75 VDD=VDD
+ VSS=VSS
Xi_1_51 OAI21_X1 $PINS ZN=O[28] A=n_1_58 B1=drc_ipo_n6 B2=n_1_76 VDD=VDD
+ VSS=VSS
Xi_1_50 OAI21_X1 $PINS ZN=O[27] A=n_1_58 B1=drc_ipo_n6 B2=n_1_77 VDD=VDD
+ VSS=VSS
Xi_1_49 OAI21_X1 $PINS ZN=O[26] A=n_1_58 B1=drc_ipo_n6 B2=n_1_78 VDD=VDD
+ VSS=VSS
Xi_1_48 OAI21_X1 $PINS ZN=O[25] A=n_1_58 B1=drc_ipo_n6 B2=n_1_79 VDD=VDD
+ VSS=VSS
Xi_1_47 OAI21_X1 $PINS ZN=O[24] A=n_1_58 B1=drc_ipo_n6 B2=n_1_80 VDD=VDD
+ VSS=VSS
Xi_1_46 OAI21_X1 $PINS ZN=O[23] A=n_1_58 B1=drc_ipo_n6 B2=n_1_81 VDD=VDD
+ VSS=VSS
Xi_1_45 NOR2_X1 $PINS ZN=n_1_35 A1=n_1_58 A2=n_1_36 VDD=VDD VSS=VSS
Xi_1_44 AOI221_X1 $PINS ZN=n_1_34 A=n_1_35 B1=n_1_40 B2=n_1_59 C1=n_1_62
+ C2=n_1_50 VDD=VDD VSS=VSS
Xi_1_43 NAND2_X1 $PINS ZN=n_1_33 A1=n_1_58 A2=n_1_36 VDD=VDD VSS=VSS
Xi_1_42 OAI21_X1 $PINS ZN=O[22] A=drc_ipo_n5 B1=n_1_33 B2=n_1_104 VDD=VDD
+ VSS=VSS
Xi_1_41 OAI21_X1 $PINS ZN=O[21] A=drc_ipo_n5 B1=n_1_33 B2=n_1_103 VDD=VDD
+ VSS=VSS
Xi_1_40 OAI21_X1 $PINS ZN=O[20] A=drc_ipo_n5 B1=n_1_33 B2=n_1_102 VDD=VDD
+ VSS=VSS
Xi_1_39 OAI21_X1 $PINS ZN=O[19] A=drc_ipo_n5 B1=n_1_33 B2=n_1_101 VDD=VDD
+ VSS=VSS
Xi_1_38 OAI21_X1 $PINS ZN=O[18] A=drc_ipo_n5 B1=n_1_33 B2=n_1_100 VDD=VDD
+ VSS=VSS
Xi_1_37 OAI21_X1 $PINS ZN=O[17] A=drc_ipo_n5 B1=n_1_33 B2=n_1_99 VDD=VDD
+ VSS=VSS
Xi_1_36 OAI21_X1 $PINS ZN=O[16] A=drc_ipo_n5 B1=n_1_33 B2=n_1_98 VDD=VDD
+ VSS=VSS
Xi_1_35 OAI21_X1 $PINS ZN=O[15] A=drc_ipo_n5 B1=n_1_33 B2=n_1_97 VDD=VDD
+ VSS=VSS
Xi_1_34 OAI21_X1 $PINS ZN=O[14] A=drc_ipo_n5 B1=n_1_33 B2=n_1_96 VDD=VDD
+ VSS=VSS
Xi_1_33 OAI21_X1 $PINS ZN=O[13] A=drc_ipo_n5 B1=n_1_33 B2=n_1_95 VDD=VDD
+ VSS=VSS
Xi_1_32 OAI21_X1 $PINS ZN=O[12] A=drc_ipo_n5 B1=n_1_33 B2=n_1_94 VDD=VDD
+ VSS=VSS
Xi_1_31 OAI21_X1 $PINS ZN=O[11] A=drc_ipo_n5 B1=n_1_33 B2=n_1_93 VDD=VDD
+ VSS=VSS
Xi_1_30 OAI21_X1 $PINS ZN=O[10] A=drc_ipo_n5 B1=n_1_33 B2=n_1_92 VDD=VDD
+ VSS=VSS
Xi_1_29 OAI21_X1 $PINS ZN=O[9] A=drc_ipo_n5 B1=n_1_33 B2=n_1_91 VDD=VDD VSS=VSS
Xi_1_28 OAI21_X1 $PINS ZN=O[8] A=drc_ipo_n5 B1=n_1_33 B2=n_1_90 VDD=VDD VSS=VSS
Xi_1_27 OAI21_X1 $PINS ZN=O[7] A=drc_ipo_n5 B1=n_1_33 B2=n_1_89 VDD=VDD VSS=VSS
Xi_1_26 OAI21_X1 $PINS ZN=O[6] A=drc_ipo_n5 B1=n_1_33 B2=n_1_88 VDD=VDD VSS=VSS
Xi_1_25 OAI21_X1 $PINS ZN=O[5] A=drc_ipo_n5 B1=n_1_33 B2=n_1_87 VDD=VDD VSS=VSS
Xi_1_24 OAI21_X1 $PINS ZN=O[4] A=drc_ipo_n5 B1=n_1_33 B2=n_1_86 VDD=VDD VSS=VSS
Xi_1_23 OAI21_X1 $PINS ZN=O[3] A=drc_ipo_n5 B1=n_1_33 B2=n_1_85 VDD=VDD VSS=VSS
Xi_1_22 OAI21_X1 $PINS ZN=O[2] A=drc_ipo_n5 B1=n_1_33 B2=n_1_84 VDD=VDD VSS=VSS
Xi_1_21 OAI21_X1 $PINS ZN=O[1] A=drc_ipo_n5 B1=n_1_33 B2=n_1_83 VDD=VDD VSS=VSS
Xi_1_20 OAI21_X1 $PINS ZN=O[0] A=drc_ipo_n5 B1=n_1_33 B2=n_1_82 VDD=VDD VSS=VSS
Xi_1_19 NOR2_X1 $PINS ZN=n_1_32 A1=B[30] A2=A[30] VDD=VDD VSS=VSS
Xi_1_18 XNOR2_X1 $PINS ZN=n_1_31 A=n_1_23 B=n_1_32 VDD=VDD VSS=VSS
Xi_1_17 NOR2_X1 $PINS ZN=OF A1=n_1_33 A2=n_1_31 VDD=VDD VSS=VSS
Xi_1_16 OR2_X1 $PINS ZN=n_1_1 A1=B[23] A2=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_15 XNOR2_X1 $PINS ZN=n_1_0 A=B[23] B=o_mantissa[47] VDD=VDD VSS=VSS
Xi_1_14 XNOR2_X1 $PINS ZN=n_1_14 A=B[30] B=A[30] VDD=VDD VSS=VSS
Xi_1_13 FA_X1 $PINS CO=n_1_23 S=n_1_30 A=n_1_13 B=n_1_14 CI=n_1_22 VDD=VDD
+ VSS=VSS
Xi_1_12 FA_X1 $PINS CO=n_1_22 S=n_1_29 A=n_1_11 B=n_1_12 CI=n_1_21 VDD=VDD
+ VSS=VSS
Xi_1_11 FA_X1 $PINS CO=n_1_21 S=n_1_28 A=n_1_9 B=n_1_10 CI=n_1_20 VDD=VDD
+ VSS=VSS
Xi_1_10 FA_X1 $PINS CO=n_1_20 S=n_1_27 A=n_1_7 B=n_1_8 CI=n_1_19 VDD=VDD
+ VSS=VSS
Xi_1_9 FA_X1 $PINS CO=n_1_19 S=n_1_26 A=n_1_5 B=n_1_6 CI=n_1_18 VDD=VDD VSS=VSS
Xi_1_8 FA_X1 $PINS CO=n_1_18 S=n_1_25 A=n_1_3 B=n_1_4 CI=n_1_17 VDD=VDD VSS=VSS
Xi_1_7 FA_X1 $PINS CO=n_1_17 S=n_1_24 A=n_1_1 B=n_1_2 CI=n_1_16 VDD=VDD VSS=VSS
Xi_1_6 HA_X1 $PINS CO=n_1_16 S=n_1_15 A=A[23] B=n_1_0 VDD=VDD VSS=VSS
Xi_1_5 HA_X1 $PINS CO=n_1_13 S=n_1_12 A=B[29] B=A[29] VDD=VDD VSS=VSS
Xi_1_4 HA_X1 $PINS CO=n_1_11 S=n_1_10 A=B[28] B=A[28] VDD=VDD VSS=VSS
Xi_1_3 HA_X1 $PINS CO=n_1_9 S=n_1_8 A=B[27] B=A[27] VDD=VDD VSS=VSS
Xi_1_2 HA_X1 $PINS CO=n_1_7 S=n_1_6 A=B[26] B=A[26] VDD=VDD VSS=VSS
Xi_1_1 HA_X1 $PINS CO=n_1_5 S=n_1_4 A=B[25] B=A[25] VDD=VDD VSS=VSS
Xi_1_0 HA_X1 $PINS CO=n_1_3 S=n_1_2 A=B[24] B=A[24] VDD=VDD VSS=VSS
Xi_5 datapath__0_5 $PINS O_final_mantessa[22]=n_22 O_final_mantessa[21]=n_21
+ O_final_mantessa[20]=n_20 O_final_mantessa[19]=n_19 O_final_mantessa[18]=n_18
+ O_final_mantessa[17]=n_17 O_final_mantessa[16]=n_16 O_final_mantessa[15]=n_15
+ O_final_mantessa[14]=n_14 O_final_mantessa[13]=n_13 O_final_mantessa[12]=n_12
+ O_final_mantessa[11]=n_11 O_final_mantessa[10]=n_10 O_final_mantessa[9]=n_9
+ O_final_mantessa[8]=n_8 O_final_mantessa[7]=n_7 O_final_mantessa[6]=n_6
+ O_final_mantessa[5]=n_5 O_final_mantessa[4]=n_4 O_final_mantessa[3]=n_3
+ O_final_mantessa[2]=n_2 O_final_mantessa[1]=n_1 O_final_mantessa[0]=n_0
+ p_0[22]=VSS p_0[21]=VSS p_0[20]=VSS p_0[19]=VSS p_0[18]=VSS p_0[17]=VSS
+ p_0[16]=VSS p_0[15]=VSS p_0[14]=VSS p_0[13]=VSS p_0[12]=VSS p_0[11]=VSS
+ p_0[10]=VSS p_0[9]=VSS p_0[8]=VSS p_0[7]=VSS p_0[6]=VSS p_0[5]=VSS p_0[4]=VSS
+ p_0[3]=VSS p_0[2]=VSS p_0[1]=VSS p_0[0]=n_46 p_1[22]=n_45 p_1[21]=n_44
+ p_1[20]=n_43 p_1[19]=n_42 p_1[18]=n_41 p_1[17]=n_40 p_1[16]=n_39 p_1[15]=n_38
+ p_1[14]=n_37 p_1[13]=n_36 p_1[12]=n_35 p_1[11]=n_34 p_1[10]=n_33 p_1[9]=n_32
+ p_1[8]=n_31 p_1[7]=n_30 p_1[6]=n_29 p_1[5]=n_28 p_1[4]=n_27 p_1[3]=n_26
+ p_1[2]=n_25 p_1[1]=n_24 p_1[0]=n_23 VDD=VDD VSS=VSS
Xi_0 datapath $PINS o_mantissa[47]=o_mantissa[47] o_mantissa[46]=o_mantissa[46]
+ o_mantissa[45]=o_mantissa[45] o_mantissa[44]=o_mantissa[44]
+ o_mantissa[43]=o_mantissa[43] o_mantissa[42]=o_mantissa[42]
+ o_mantissa[41]=o_mantissa[41] o_mantissa[40]=o_mantissa[40]
+ o_mantissa[39]=o_mantissa[39] o_mantissa[38]=o_mantissa[38]
+ o_mantissa[37]=o_mantissa[37] o_mantissa[36]=o_mantissa[36]
+ o_mantissa[35]=o_mantissa[35] o_mantissa[34]=o_mantissa[34]
+ o_mantissa[33]=o_mantissa[33] o_mantissa[32]=o_mantissa[32]
+ o_mantissa[31]=o_mantissa[31] o_mantissa[30]=o_mantissa[30]
+ o_mantissa[29]=o_mantissa[29] o_mantissa[28]=o_mantissa[28]
+ o_mantissa[27]=o_mantissa[27] o_mantissa[26]=o_mantissa[26]
+ o_mantissa[25]=o_mantissa[25] o_mantissa[24]=o_mantissa[24]
+ o_mantissa[23]=o_mantissa[23] o_mantissa[22]=o_mantissa[22]
+ o_mantissa[21]=o_mantissa[21] o_mantissa[20]=o_mantissa[20]
+ o_mantissa[19]=o_mantissa[19] o_mantissa[18]=o_mantissa[18]
+ o_mantissa[17]=o_mantissa[17] o_mantissa[16]=o_mantissa[16]
+ o_mantissa[15]=o_mantissa[15] o_mantissa[14]=o_mantissa[14]
+ o_mantissa[13]=o_mantissa[13] o_mantissa[12]=o_mantissa[12]
+ o_mantissa[11]=o_mantissa[11] o_mantissa[10]=o_mantissa[10]
+ o_mantissa[9]=o_mantissa[9] o_mantissa[8]=o_mantissa[8]
+ o_mantissa[7]=o_mantissa[7] o_mantissa[6]=o_mantissa[6]
+ o_mantissa[5]=o_mantissa[5] o_mantissa[4]=o_mantissa[4]
+ o_mantissa[3]=o_mantissa[3] o_mantissa[2]=o_mantissa[2]
+ o_mantissa[1]=o_mantissa[1] o_mantissa[0]=o_mantissa[0] a_mantissa[23]=uc_1
+ a_mantissa[22]=A[22] a_mantissa[21]=A[21] a_mantissa[20]=A[20]
+ a_mantissa[19]=A[19] a_mantissa[18]=A[18] a_mantissa[17]=A[17]
+ a_mantissa[16]=A[16] a_mantissa[15]=A[15] a_mantissa[14]=A[14]
+ a_mantissa[13]=A[13] a_mantissa[12]=A[12] a_mantissa[11]=A[11]
+ a_mantissa[10]=A[10] a_mantissa[9]=A[9] a_mantissa[8]=A[8] a_mantissa[7]=A[7]
+ a_mantissa[6]=A[6] a_mantissa[5]=A[5] a_mantissa[4]=A[4] a_mantissa[3]=A[3]
+ a_mantissa[2]=A[2] a_mantissa[1]=A[1] a_mantissa[0]=A[0] b_mantissa[23]=uc_0
+ b_mantissa[22]=B[22] b_mantissa[21]=B[21] b_mantissa[20]=B[20]
+ b_mantissa[19]=B[19] b_mantissa[18]=B[18] b_mantissa[17]=B[17]
+ b_mantissa[16]=B[16] b_mantissa[15]=B[15] b_mantissa[14]=B[14]
+ b_mantissa[13]=B[13] b_mantissa[12]=B[12] b_mantissa[11]=B[11]
+ b_mantissa[10]=B[10] b_mantissa[9]=B[9] b_mantissa[8]=B[8] b_mantissa[7]=B[7]
+ b_mantissa[6]=B[6] b_mantissa[5]=B[5] b_mantissa[4]=B[4] b_mantissa[3]=B[3]
+ b_mantissa[2]=B[2] b_mantissa[1]=B[1] b_mantissa[0]=B[0] VDD=VDD VSS=VSS
Xdrc_ipo_c5 CLKBUF_X1 $PINS Z=drc_ipo_n5 A=n_1_34 VDD=VDD VSS=VSS
Xdrc_ipo_c6 CLKBUF_X1 $PINS Z=drc_ipo_n6 A=n_1_37 VDD=VDD VSS=VSS
.ENDS

.SUBCKT registerNbits__0_21 VDD VSS clk reset en inp[31] inp[30] inp[29]
+ inp[28] inp[27] inp[26] inp[25] inp[24] inp[23] inp[22] inp[21] inp[20]
+ inp[19] inp[18] inp[17] inp[16] inp[15] inp[14] inp[13] inp[12] inp[11]
+ inp[10] inp[9] inp[8] inp[7] inp[6] inp[5] inp[4] inp[3] inp[2] inp[1] inp[0]
+ out[31] out[30] out[29] out[28] out[27] out[26] out[25] out[24] out[23]
+ out[22] out[21] out[20] out[19] out[18] out[17] out[16] out[15] out[14]
+ out[13] out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5] out[4]
+ out[3] out[2] out[1] out[0]
Xi_0_33 AND2_X1 $PINS ZN=n_33 A1=n_0_0 A2=inp[31] VDD=VDD VSS=VSS
Xi_0_32 AND2_X1 $PINS ZN=n_32 A1=n_0_0 A2=inp[30] VDD=VDD VSS=VSS
Xi_0_31 AND2_X1 $PINS ZN=n_31 A1=n_0_0 A2=inp[29] VDD=VDD VSS=VSS
Xi_0_30 AND2_X1 $PINS ZN=n_30 A1=n_0_0 A2=inp[28] VDD=VDD VSS=VSS
Xi_0_29 AND2_X1 $PINS ZN=n_29 A1=n_0_0 A2=inp[27] VDD=VDD VSS=VSS
Xi_0_28 AND2_X1 $PINS ZN=n_28 A1=n_0_0 A2=inp[26] VDD=VDD VSS=VSS
Xi_0_27 AND2_X1 $PINS ZN=n_27 A1=n_0_0 A2=inp[25] VDD=VDD VSS=VSS
Xi_0_26 AND2_X1 $PINS ZN=n_26 A1=n_0_0 A2=inp[24] VDD=VDD VSS=VSS
Xi_0_25 AND2_X1 $PINS ZN=n_25 A1=n_0_0 A2=inp[23] VDD=VDD VSS=VSS
Xi_0_24 AND2_X1 $PINS ZN=n_24 A1=n_0_0 A2=inp[22] VDD=VDD VSS=VSS
Xi_0_23 AND2_X1 $PINS ZN=n_23 A1=n_0_0 A2=inp[21] VDD=VDD VSS=VSS
Xi_0_22 AND2_X1 $PINS ZN=n_22 A1=n_0_0 A2=inp[20] VDD=VDD VSS=VSS
Xi_0_21 AND2_X1 $PINS ZN=n_21 A1=n_0_0 A2=inp[19] VDD=VDD VSS=VSS
Xi_0_20 AND2_X1 $PINS ZN=n_20 A1=n_0_0 A2=inp[18] VDD=VDD VSS=VSS
Xi_0_19 AND2_X1 $PINS ZN=n_19 A1=n_0_0 A2=inp[17] VDD=VDD VSS=VSS
Xi_0_18 AND2_X1 $PINS ZN=n_18 A1=n_0_0 A2=inp[16] VDD=VDD VSS=VSS
Xi_0_17 AND2_X1 $PINS ZN=n_17 A1=n_0_0 A2=inp[15] VDD=VDD VSS=VSS
Xi_0_16 AND2_X1 $PINS ZN=n_16 A1=n_0_0 A2=inp[14] VDD=VDD VSS=VSS
Xi_0_15 AND2_X1 $PINS ZN=n_15 A1=n_0_0 A2=inp[13] VDD=VDD VSS=VSS
Xi_0_14 AND2_X1 $PINS ZN=n_14 A1=n_0_0 A2=inp[12] VDD=VDD VSS=VSS
Xi_0_13 AND2_X1 $PINS ZN=n_13 A1=n_0_0 A2=inp[11] VDD=VDD VSS=VSS
Xi_0_12 AND2_X1 $PINS ZN=n_12 A1=n_0_0 A2=inp[10] VDD=VDD VSS=VSS
Xi_0_11 AND2_X1 $PINS ZN=n_11 A1=n_0_0 A2=inp[9] VDD=VDD VSS=VSS
Xi_0_10 AND2_X1 $PINS ZN=n_10 A1=n_0_0 A2=inp[8] VDD=VDD VSS=VSS
Xi_0_9 AND2_X1 $PINS ZN=n_9 A1=n_0_0 A2=inp[7] VDD=VDD VSS=VSS
Xi_0_8 AND2_X1 $PINS ZN=n_8 A1=n_0_0 A2=inp[6] VDD=VDD VSS=VSS
Xi_0_7 AND2_X1 $PINS ZN=n_7 A1=n_0_0 A2=inp[5] VDD=VDD VSS=VSS
Xi_0_6 AND2_X1 $PINS ZN=n_6 A1=n_0_0 A2=inp[4] VDD=VDD VSS=VSS
Xi_0_5 AND2_X1 $PINS ZN=n_5 A1=n_0_0 A2=inp[3] VDD=VDD VSS=VSS
Xi_0_4 AND2_X1 $PINS ZN=n_4 A1=n_0_0 A2=inp[2] VDD=VDD VSS=VSS
Xi_0_3 AND2_X1 $PINS ZN=n_3 A1=n_0_0 A2=inp[1] VDD=VDD VSS=VSS
Xi_0_2 AND2_X1 $PINS ZN=n_2 A1=n_0_0 A2=inp[0] VDD=VDD VSS=VSS
Xi_0_1 INV_X1 $PINS ZN=n_0_0 A=reset VDD=VDD VSS=VSS
Xi_0_0 OR2_X1 $PINS ZN=n_1 A1=en A2=reset VDD=VDD VSS=VSS
Xout_reg[0] DFF_X1 $PINS Q=out[0] CK=n_0 D=n_2 VDD=VDD VSS=VSS
Xout_reg[1] DFF_X1 $PINS Q=out[1] CK=n_0 D=n_3 VDD=VDD VSS=VSS
Xout_reg[2] DFF_X1 $PINS Q=out[2] CK=n_0 D=n_4 VDD=VDD VSS=VSS
Xout_reg[3] DFF_X1 $PINS Q=out[3] CK=n_0 D=n_5 VDD=VDD VSS=VSS
Xout_reg[4] DFF_X1 $PINS Q=out[4] CK=n_0 D=n_6 VDD=VDD VSS=VSS
Xout_reg[5] DFF_X1 $PINS Q=out[5] CK=n_0 D=n_7 VDD=VDD VSS=VSS
Xout_reg[6] DFF_X1 $PINS Q=out[6] CK=n_0 D=n_8 VDD=VDD VSS=VSS
Xout_reg[7] DFF_X1 $PINS Q=out[7] CK=n_0 D=n_9 VDD=VDD VSS=VSS
Xout_reg[8] DFF_X1 $PINS Q=out[8] CK=n_0 D=n_10 VDD=VDD VSS=VSS
Xout_reg[9] DFF_X1 $PINS Q=out[9] CK=n_0 D=n_11 VDD=VDD VSS=VSS
Xout_reg[10] DFF_X1 $PINS Q=out[10] CK=n_0 D=n_12 VDD=VDD VSS=VSS
Xout_reg[11] DFF_X1 $PINS Q=out[11] CK=n_0 D=n_13 VDD=VDD VSS=VSS
Xout_reg[12] DFF_X1 $PINS Q=out[12] CK=n_0 D=n_14 VDD=VDD VSS=VSS
Xout_reg[13] DFF_X1 $PINS Q=out[13] CK=n_0 D=n_15 VDD=VDD VSS=VSS
Xout_reg[14] DFF_X1 $PINS Q=out[14] CK=n_0 D=n_16 VDD=VDD VSS=VSS
Xout_reg[15] DFF_X1 $PINS Q=out[15] CK=n_0 D=n_17 VDD=VDD VSS=VSS
Xout_reg[16] DFF_X1 $PINS Q=out[16] CK=n_0 D=n_18 VDD=VDD VSS=VSS
Xout_reg[17] DFF_X1 $PINS Q=out[17] CK=n_0 D=n_19 VDD=VDD VSS=VSS
Xout_reg[18] DFF_X1 $PINS Q=out[18] CK=n_0 D=n_20 VDD=VDD VSS=VSS
Xout_reg[19] DFF_X1 $PINS Q=out[19] CK=n_0 D=n_21 VDD=VDD VSS=VSS
Xout_reg[20] DFF_X1 $PINS Q=out[20] CK=n_0 D=n_22 VDD=VDD VSS=VSS
Xout_reg[21] DFF_X1 $PINS Q=out[21] CK=n_0 D=n_23 VDD=VDD VSS=VSS
Xout_reg[22] DFF_X1 $PINS Q=out[22] CK=n_0 D=n_24 VDD=VDD VSS=VSS
Xout_reg[23] DFF_X1 $PINS Q=out[23] CK=n_0 D=n_25 VDD=VDD VSS=VSS
Xout_reg[24] DFF_X1 $PINS Q=out[24] CK=n_0 D=n_26 VDD=VDD VSS=VSS
Xout_reg[25] DFF_X1 $PINS Q=out[25] CK=n_0 D=n_27 VDD=VDD VSS=VSS
Xout_reg[26] DFF_X1 $PINS Q=out[26] CK=n_0 D=n_28 VDD=VDD VSS=VSS
Xout_reg[27] DFF_X1 $PINS Q=out[27] CK=n_0 D=n_29 VDD=VDD VSS=VSS
Xout_reg[28] DFF_X1 $PINS Q=out[28] CK=n_0 D=n_30 VDD=VDD VSS=VSS
Xout_reg[29] DFF_X1 $PINS Q=out[29] CK=n_0 D=n_31 VDD=VDD VSS=VSS
Xout_reg[30] DFF_X1 $PINS Q=out[30] CK=n_0 D=n_32 VDD=VDD VSS=VSS
Xout_reg[31] DFF_X1 $PINS Q=out[31] CK=n_0 D=n_33 VDD=VDD VSS=VSS
Xclk_gate_out_reg CLKGATETST_X1 $PINS GCK=n_0 CK=clk E=n_1 SE=VSS VDD=VDD
+ VSS=VSS
.ENDS

.SUBCKT registerNbits__0_18 VDD VSS clk reset en inp[31] inp[30] inp[29]
+ inp[28] inp[27] inp[26] inp[25] inp[24] inp[23] inp[22] inp[21] inp[20]
+ inp[19] inp[18] inp[17] inp[16] inp[15] inp[14] inp[13] inp[12] inp[11]
+ inp[10] inp[9] inp[8] inp[7] inp[6] inp[5] inp[4] inp[3] inp[2] inp[1] inp[0]
+ out[31] out[30] out[29] out[28] out[27] out[26] out[25] out[24] out[23]
+ out[22] out[21] out[20] out[19] out[18] out[17] out[16] out[15] out[14]
+ out[13] out[12] out[11] out[10] out[9] out[8] out[7] out[6] out[5] out[4]
+ out[3] out[2] out[1] out[0]
Xi_0_33 AND2_X1 $PINS ZN=n_33 A1=n_0_0 A2=inp[31] VDD=VDD VSS=VSS
Xi_0_32 AND2_X1 $PINS ZN=n_32 A1=n_0_0 A2=inp[30] VDD=VDD VSS=VSS
Xi_0_31 AND2_X1 $PINS ZN=n_31 A1=n_0_0 A2=inp[29] VDD=VDD VSS=VSS
Xi_0_30 AND2_X1 $PINS ZN=n_30 A1=n_0_0 A2=inp[28] VDD=VDD VSS=VSS
Xi_0_29 AND2_X1 $PINS ZN=n_29 A1=n_0_0 A2=inp[27] VDD=VDD VSS=VSS
Xi_0_28 AND2_X1 $PINS ZN=n_28 A1=n_0_0 A2=inp[26] VDD=VDD VSS=VSS
Xi_0_27 AND2_X1 $PINS ZN=n_27 A1=n_0_0 A2=inp[25] VDD=VDD VSS=VSS
Xi_0_26 AND2_X1 $PINS ZN=n_26 A1=n_0_0 A2=inp[24] VDD=VDD VSS=VSS
Xi_0_25 AND2_X1 $PINS ZN=n_25 A1=n_0_0 A2=inp[23] VDD=VDD VSS=VSS
Xi_0_24 AND2_X1 $PINS ZN=n_24 A1=n_0_0 A2=inp[22] VDD=VDD VSS=VSS
Xi_0_23 AND2_X1 $PINS ZN=n_23 A1=n_0_0 A2=inp[21] VDD=VDD VSS=VSS
Xi_0_22 AND2_X1 $PINS ZN=n_22 A1=n_0_0 A2=inp[20] VDD=VDD VSS=VSS
Xi_0_21 AND2_X1 $PINS ZN=n_21 A1=n_0_0 A2=inp[19] VDD=VDD VSS=VSS
Xi_0_20 AND2_X1 $PINS ZN=n_20 A1=n_0_0 A2=inp[18] VDD=VDD VSS=VSS
Xi_0_19 AND2_X1 $PINS ZN=n_19 A1=n_0_0 A2=inp[17] VDD=VDD VSS=VSS
Xi_0_18 AND2_X1 $PINS ZN=n_18 A1=n_0_0 A2=inp[16] VDD=VDD VSS=VSS
Xi_0_17 AND2_X1 $PINS ZN=n_17 A1=n_0_0 A2=inp[15] VDD=VDD VSS=VSS
Xi_0_16 AND2_X1 $PINS ZN=n_16 A1=n_0_0 A2=inp[14] VDD=VDD VSS=VSS
Xi_0_15 AND2_X1 $PINS ZN=n_15 A1=n_0_0 A2=inp[13] VDD=VDD VSS=VSS
Xi_0_14 AND2_X1 $PINS ZN=n_14 A1=n_0_0 A2=inp[12] VDD=VDD VSS=VSS
Xi_0_13 AND2_X1 $PINS ZN=n_13 A1=n_0_0 A2=inp[11] VDD=VDD VSS=VSS
Xi_0_12 AND2_X1 $PINS ZN=n_12 A1=n_0_0 A2=inp[10] VDD=VDD VSS=VSS
Xi_0_11 AND2_X1 $PINS ZN=n_11 A1=n_0_0 A2=inp[9] VDD=VDD VSS=VSS
Xi_0_10 AND2_X1 $PINS ZN=n_10 A1=n_0_0 A2=inp[8] VDD=VDD VSS=VSS
Xi_0_9 AND2_X1 $PINS ZN=n_9 A1=n_0_0 A2=inp[7] VDD=VDD VSS=VSS
Xi_0_8 AND2_X1 $PINS ZN=n_8 A1=n_0_0 A2=inp[6] VDD=VDD VSS=VSS
Xi_0_7 AND2_X1 $PINS ZN=n_7 A1=n_0_0 A2=inp[5] VDD=VDD VSS=VSS
Xi_0_6 AND2_X1 $PINS ZN=n_6 A1=n_0_0 A2=inp[4] VDD=VDD VSS=VSS
Xi_0_5 AND2_X1 $PINS ZN=n_5 A1=n_0_0 A2=inp[3] VDD=VDD VSS=VSS
Xi_0_4 AND2_X1 $PINS ZN=n_4 A1=n_0_0 A2=inp[2] VDD=VDD VSS=VSS
Xi_0_3 AND2_X1 $PINS ZN=n_3 A1=n_0_0 A2=inp[1] VDD=VDD VSS=VSS
Xi_0_2 AND2_X1 $PINS ZN=n_2 A1=n_0_0 A2=inp[0] VDD=VDD VSS=VSS
Xi_0_1 INV_X2 $PINS ZN=n_0_0 A=reset VDD=VDD VSS=VSS
Xi_0_0 OR2_X1 $PINS ZN=n_1 A1=en A2=reset VDD=VDD VSS=VSS
Xout_reg[0] DFF_X1 $PINS Q=out[0] CK=n_0 D=n_2 VDD=VDD VSS=VSS
Xout_reg[1] DFF_X1 $PINS Q=out[1] CK=n_0 D=n_3 VDD=VDD VSS=VSS
Xout_reg[2] DFF_X1 $PINS Q=out[2] CK=n_0 D=n_4 VDD=VDD VSS=VSS
Xout_reg[3] DFF_X1 $PINS Q=out[3] CK=n_0 D=n_5 VDD=VDD VSS=VSS
Xout_reg[4] DFF_X1 $PINS Q=out[4] CK=n_0 D=n_6 VDD=VDD VSS=VSS
Xout_reg[5] DFF_X1 $PINS Q=out[5] CK=n_0 D=n_7 VDD=VDD VSS=VSS
Xout_reg[6] DFF_X1 $PINS Q=out[6] CK=n_0 D=n_8 VDD=VDD VSS=VSS
Xout_reg[7] DFF_X1 $PINS Q=out[7] CK=n_0 D=n_9 VDD=VDD VSS=VSS
Xout_reg[8] DFF_X1 $PINS Q=out[8] CK=n_0 D=n_10 VDD=VDD VSS=VSS
Xout_reg[9] DFF_X1 $PINS Q=out[9] CK=n_0 D=n_11 VDD=VDD VSS=VSS
Xout_reg[10] DFF_X1 $PINS Q=out[10] CK=n_0 D=n_12 VDD=VDD VSS=VSS
Xout_reg[11] DFF_X1 $PINS Q=out[11] CK=n_0 D=n_13 VDD=VDD VSS=VSS
Xout_reg[12] DFF_X1 $PINS Q=out[12] CK=n_0 D=n_14 VDD=VDD VSS=VSS
Xout_reg[13] DFF_X1 $PINS Q=out[13] CK=n_0 D=n_15 VDD=VDD VSS=VSS
Xout_reg[14] DFF_X1 $PINS Q=out[14] CK=n_0 D=n_16 VDD=VDD VSS=VSS
Xout_reg[15] DFF_X1 $PINS Q=out[15] CK=n_0 D=n_17 VDD=VDD VSS=VSS
Xout_reg[16] DFF_X1 $PINS Q=out[16] CK=n_0 D=n_18 VDD=VDD VSS=VSS
Xout_reg[17] DFF_X1 $PINS Q=out[17] CK=n_0 D=n_19 VDD=VDD VSS=VSS
Xout_reg[18] DFF_X1 $PINS Q=out[18] CK=n_0 D=n_20 VDD=VDD VSS=VSS
Xout_reg[19] DFF_X1 $PINS Q=out[19] CK=n_0 D=n_21 VDD=VDD VSS=VSS
Xout_reg[20] DFF_X1 $PINS Q=out[20] CK=n_0 D=n_22 VDD=VDD VSS=VSS
Xout_reg[21] DFF_X1 $PINS Q=out[21] CK=n_0 D=n_23 VDD=VDD VSS=VSS
Xout_reg[22] DFF_X1 $PINS Q=out[22] CK=n_0 D=n_24 VDD=VDD VSS=VSS
Xout_reg[23] DFF_X1 $PINS Q=out[23] CK=n_0 D=n_25 VDD=VDD VSS=VSS
Xout_reg[24] DFF_X1 $PINS Q=out[24] CK=n_0 D=n_26 VDD=VDD VSS=VSS
Xout_reg[25] DFF_X1 $PINS Q=out[25] CK=n_0 D=n_27 VDD=VDD VSS=VSS
Xout_reg[26] DFF_X1 $PINS Q=out[26] CK=n_0 D=n_28 VDD=VDD VSS=VSS
Xout_reg[27] DFF_X1 $PINS Q=out[27] CK=n_0 D=n_29 VDD=VDD VSS=VSS
Xout_reg[28] DFF_X1 $PINS Q=out[28] CK=n_0 D=n_30 VDD=VDD VSS=VSS
Xout_reg[29] DFF_X1 $PINS Q=out[29] CK=n_0 D=n_31 VDD=VDD VSS=VSS
Xout_reg[30] DFF_X1 $PINS Q=out[30] CK=n_0 D=n_32 VDD=VDD VSS=VSS
Xout_reg[31] DFF_X1 $PINS Q=out[31] CK=n_0 D=n_33 VDD=VDD VSS=VSS
Xclk_gate_out_reg CLKGATETST_X1 $PINS GCK=n_0 CK=clk E=n_1 SE=VSS VDD=VDD
+ VSS=VSS
.ENDS

.SUBCKT FloatingPointMultiplierSingle VSS VDD clk reset en inputA[31]
+ inputA[30] inputA[29] inputA[28] inputA[27] inputA[26] inputA[25] inputA[24]
+ inputA[23] inputA[22] inputA[21] inputA[20] inputA[19] inputA[18] inputA[17]
+ inputA[16] inputA[15] inputA[14] inputA[13] inputA[12] inputA[11] inputA[10]
+ inputA[9] inputA[8] inputA[7] inputA[6] inputA[5] inputA[4] inputA[3]
+ inputA[2] inputA[1] inputA[0] inputB[31] inputB[30] inputB[29] inputB[28]
+ inputB[27] inputB[26] inputB[25] inputB[24] inputB[23] inputB[22] inputB[21]
+ inputB[20] inputB[19] inputB[18] inputB[17] inputB[16] inputB[15] inputB[14]
+ inputB[13] inputB[12] inputB[11] inputB[10] inputB[9] inputB[8] inputB[7]
+ inputB[6] inputB[5] inputB[4] inputB[3] inputB[2] inputB[1] inputB[0]
+ result[31] result[30] result[29] result[28] result[27] result[26] result[25]
+ result[24] result[23] result[22] result[21] result[20] result[19] result[18]
+ result[17] result[16] result[15] result[14] result[13] result[12] result[11]
+ result[10] result[9] result[8] result[7] result[6] result[5] result[4]
+ result[3] result[2] result[1] result[0] OF
XoutReg registerNbits $PINS out[31]=result[31] out[30]=result[30]
+ out[29]=result[29] out[28]=result[28] out[27]=result[27] out[26]=result[26]
+ out[25]=result[25] out[24]=result[24] out[23]=result[23] out[22]=result[22]
+ out[21]=result[21] out[20]=result[20] out[19]=result[19] out[18]=result[18]
+ out[17]=result[17] out[16]=result[16] out[15]=result[15] out[14]=result[14]
+ out[13]=result[13] out[12]=result[12] out[11]=result[11] out[10]=result[10]
+ out[9]=result[9] out[8]=result[8] out[7]=result[7] out[6]=result[6]
+ out[5]=result[5] out[4]=result[4] out[3]=result[3] out[2]=result[2]
+ out[1]=result[1] out[0]=result[0] clk=clk en=en inp[31]=out[31] inp[30]=out[30]
+ inp[29]=out[29] inp[28]=out[28] inp[27]=out[27] inp[26]=out[26] inp[25]=out[25]
+ inp[24]=out[24] inp[23]=out[23] inp[22]=out[22] inp[21]=out[21] inp[20]=out[20]
+ inp[19]=out[19] inp[18]=out[18] inp[17]=out[17] inp[16]=out[16] inp[15]=out[15]
+ inp[14]=out[14] inp[13]=out[13] inp[12]=out[12] inp[11]=out[11] inp[10]=out[10]
+ inp[9]=out[9] inp[8]=out[8] inp[7]=out[7] inp[6]=out[6] inp[5]=out[5]
+ inp[4]=out[4] inp[3]=out[3] inp[2]=out[2] inp[1]=out[1] inp[0]=out[0]
+ reset=reset VDD=VDD VSS=VSS
XFloatingPointMultiplier_dut FloatingPointMultiplier $PINS OF=OF O[31]=out[31]
+ O[30]=out[30] O[29]=out[29] O[28]=out[28] O[27]=out[27] O[26]=out[26]
+ O[25]=out[25] O[24]=out[24] O[23]=out[23] O[22]=out[22] O[21]=out[21]
+ O[20]=out[20] O[19]=out[19] O[18]=out[18] O[17]=out[17] O[16]=out[16]
+ O[15]=out[15] O[14]=out[14] O[13]=out[13] O[12]=out[12] O[11]=out[11]
+ O[10]=out[10] O[9]=out[9] O[8]=out[8] O[7]=out[7] O[6]=out[6] O[5]=out[5]
+ O[4]=out[4] O[3]=out[3] O[2]=out[2] O[1]=out[1] O[0]=out[0] A[31]=A_reg[31]
+ A[30]=A_reg[30] A[29]=A_reg[29] A[28]=A_reg[28] A[27]=A_reg[27] A[26]=A_reg[26]
+ A[25]=A_reg[25] A[24]=A_reg[24] A[23]=A_reg[23] A[22]=A_reg[22] A[21]=A_reg[21]
+ A[20]=A_reg[20] A[19]=A_reg[19] A[18]=A_reg[18] A[17]=A_reg[17] A[16]=A_reg[16]
+ A[15]=A_reg[15] A[14]=A_reg[14] A[13]=A_reg[13] A[12]=A_reg[12] A[11]=A_reg[11]
+ A[10]=A_reg[10] A[9]=A_reg[9] A[8]=A_reg[8] A[7]=A_reg[7] A[6]=A_reg[6]
+ A[5]=A_reg[5] A[4]=A_reg[4] A[3]=A_reg[3] A[2]=A_reg[2] A[1]=A_reg[1]
+ A[0]=A_reg[0] B[31]=B_reg[31] B[30]=B_reg[30] B[29]=B_reg[29] B[28]=B_reg[28]
+ B[27]=B_reg[27] B[26]=B_reg[26] B[25]=B_reg[25] B[24]=B_reg[24] B[23]=B_reg[23]
+ B[22]=B_reg[22] B[21]=B_reg[21] B[20]=B_reg[20] B[19]=B_reg[19] B[18]=B_reg[18]
+ B[17]=B_reg[17] B[16]=B_reg[16] B[15]=B_reg[15] B[14]=B_reg[14] B[13]=B_reg[13]
+ B[12]=B_reg[12] B[11]=B_reg[11] B[10]=B_reg[10] B[9]=B_reg[9] B[8]=B_reg[8]
+ B[7]=B_reg[7] B[6]=B_reg[6] B[5]=B_reg[5] B[4]=B_reg[4] B[3]=B_reg[3]
+ B[2]=B_reg[2] B[1]=B_reg[1] B[0]=B_reg[0] VDD=VDD VSS=VSS
XregB registerNbits__0_21 $PINS out[31]=B_reg[31] out[30]=B_reg[30]
+ out[29]=B_reg[29] out[28]=B_reg[28] out[27]=B_reg[27] out[26]=B_reg[26]
+ out[25]=B_reg[25] out[24]=B_reg[24] out[23]=B_reg[23] out[22]=B_reg[22]
+ out[21]=B_reg[21] out[20]=B_reg[20] out[19]=B_reg[19] out[18]=B_reg[18]
+ out[17]=B_reg[17] out[16]=B_reg[16] out[15]=B_reg[15] out[14]=B_reg[14]
+ out[13]=B_reg[13] out[12]=B_reg[12] out[11]=B_reg[11] out[10]=B_reg[10]
+ out[9]=B_reg[9] out[8]=B_reg[8] out[7]=B_reg[7] out[6]=B_reg[6] out[5]=B_reg[5]
+ out[4]=B_reg[4] out[3]=B_reg[3] out[2]=B_reg[2] out[1]=B_reg[1] out[0]=B_reg[0]
+ clk=clk en=en inp[31]=inputB[31] inp[30]=inputB[30] inp[29]=inputB[29]
+ inp[28]=inputB[28] inp[27]=inputB[27] inp[26]=inputB[26] inp[25]=inputB[25]
+ inp[24]=inputB[24] inp[23]=inputB[23] inp[22]=inputB[22] inp[21]=inputB[21]
+ inp[20]=inputB[20] inp[19]=inputB[19] inp[18]=inputB[18] inp[17]=inputB[17]
+ inp[16]=inputB[16] inp[15]=inputB[15] inp[14]=inputB[14] inp[13]=inputB[13]
+ inp[12]=inputB[12] inp[11]=inputB[11] inp[10]=inputB[10] inp[9]=inputB[9]
+ inp[8]=inputB[8] inp[7]=inputB[7] inp[6]=inputB[6] inp[5]=inputB[5]
+ inp[4]=inputB[4] inp[3]=inputB[3] inp[2]=inputB[2] inp[1]=inputB[1]
+ inp[0]=inputB[0] reset=reset VDD=VDD VSS=VSS
XregA registerNbits__0_18 $PINS out[31]=A_reg[31] out[30]=A_reg[30]
+ out[29]=A_reg[29] out[28]=A_reg[28] out[27]=A_reg[27] out[26]=A_reg[26]
+ out[25]=A_reg[25] out[24]=A_reg[24] out[23]=A_reg[23] out[22]=A_reg[22]
+ out[21]=A_reg[21] out[20]=A_reg[20] out[19]=A_reg[19] out[18]=A_reg[18]
+ out[17]=A_reg[17] out[16]=A_reg[16] out[15]=A_reg[15] out[14]=A_reg[14]
+ out[13]=A_reg[13] out[12]=A_reg[12] out[11]=A_reg[11] out[10]=A_reg[10]
+ out[9]=A_reg[9] out[8]=A_reg[8] out[7]=A_reg[7] out[6]=A_reg[6] out[5]=A_reg[5]
+ out[4]=A_reg[4] out[3]=A_reg[3] out[2]=A_reg[2] out[1]=A_reg[1] out[0]=A_reg[0]
+ clk=clk en=en inp[31]=inputA[31] inp[30]=inputA[30] inp[29]=inputA[29]
+ inp[28]=inputA[28] inp[27]=inputA[27] inp[26]=inputA[26] inp[25]=inputA[25]
+ inp[24]=inputA[24] inp[23]=inputA[23] inp[22]=inputA[22] inp[21]=inputA[21]
+ inp[20]=inputA[20] inp[19]=inputA[19] inp[18]=inputA[18] inp[17]=inputA[17]
+ inp[16]=inputA[16] inp[15]=inputA[15] inp[14]=inputA[14] inp[13]=inputA[13]
+ inp[12]=inputA[12] inp[11]=inputA[11] inp[10]=inputA[10] inp[9]=inputA[9]
+ inp[8]=inputA[8] inp[7]=inputA[7] inp[6]=inputA[6] inp[5]=inputA[5]
+ inp[4]=inputA[4] inp[3]=inputA[3] inp[2]=inputA[2] inp[1]=inputA[1]
+ inp[0]=inputA[0] reset=reset VDD=VDD VSS=VSS
.ENDS
.GLOBAL VDD
.GLOBAL VSS
